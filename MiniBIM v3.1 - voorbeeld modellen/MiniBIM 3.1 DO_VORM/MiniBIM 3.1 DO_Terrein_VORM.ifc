Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: MiniBIM 3.1 DO_Terrein_VORM.ifc
Time: 2025-11-28T10:26:52+01:00
Written by: IfcOpenShell 0.8.2
Made in: Bonsai 0.8.2
Authorization: Nobody

# IfcSpace: Terrein (5)
In: 00 begane grond
PredefinedType: USERDEFINED
Name | TerreinType | GrossFloorArea (m2) = NetFloorArea (m2) | GrossPerimeter (m) | Bepalingsmethode
Kadastraal perceel | Kadastraal perceel | 4308.31 | 275.6
Onbebouwde terreinoppervlakte | Terreinoppervlakte | 1691.2 | 519.2 | Onbebouwde terreinoppervlakte
Bouwwerkperceel | Bouwwerkperceel | 3773.11 | 259.6
Bebouwde terreinoppervlakte | Terreinoppervlakte | 2575.11 | 219.6 | Bebouwde terreinoppervlakte
Overbouwde terreinoppervlakte | Terreinoppervlakte | 42 | 66 | Overbouwde terreinoppervlakte
