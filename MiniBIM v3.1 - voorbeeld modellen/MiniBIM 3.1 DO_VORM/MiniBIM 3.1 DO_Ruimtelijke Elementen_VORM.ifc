Properties of the parts of a building model (IFC4), part 7 of 12

# IfcSpace: Area:1699540
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.06.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 91.3625 m2; NetFloorArea: 91.3625 m2; GrossCeilingArea: 91.3625 m2

# IfcSpace: Area:1699541
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.06.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.06.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSH; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 88.035 m2; NetFloorArea: 88.035 m2; GrossCeilingArea: 88.035 m2

# IfcSpace: Area:1699542
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.06.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.06.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSH; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 89.82 m2; NetFloorArea: 89.82 m2; GrossCeilingArea: 89.82 m2

# IfcSpace: Area:1699543
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.06.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.06.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 87.4095 m2; NetFloorArea: 87.4095 m2; GrossCeilingArea: 87.4095 m2

# IfcSpace: Area:1699545
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 01; 01.07.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.07.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSK; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 83.002 m2; NetFloorArea: 83.002 m2; GrossCeilingArea: 83.002 m2

# IfcSpace: Area:1699546
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 01; 01.07.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.07.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSK; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.9 m2; NetFloorArea: 90.9 m2; GrossCeilingArea: 90.9 m2

# IfcSpace: Area:1699547
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 01; 01.07.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.07.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 91.3625 m2; NetFloorArea: 91.3625 m2; GrossCeilingArea: 91.3625 m2

# IfcSpace: Area:1699548
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 01; 01.07.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.07.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSK; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 88.035 m2; NetFloorArea: 88.035 m2; GrossCeilingArea: 88.035 m2

# IfcSpace: Area:1699549
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 01; 01.07.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.07.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSK; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 89.82 m2; NetFloorArea: 89.82 m2; GrossCeilingArea: 89.82 m2

# IfcSpace: Area:1699550
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 01; 01.07.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.07.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 87.4095 m2; NetFloorArea: 87.4095 m2; GrossCeilingArea: 87.4095 m2

# IfcSpace: Area:1699552
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 02; 02.07.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.07.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSH; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 83.002 m2; NetFloorArea: 83.002 m2; GrossCeilingArea: 83.002 m2

# IfcSpace: Area:1699553
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 02; 02.07.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.07.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.9 m2; NetFloorArea: 90.9 m2; GrossCeilingArea: 90.9 m2

# IfcSpace: Area:1699554
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 02; 02.07.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.07.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 91.3625 m2; NetFloorArea: 91.3625 m2; GrossCeilingArea: 91.3625 m2

# IfcSpace: Area:1699555
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 02; 02.07.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.07.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSH; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 88.035 m2; NetFloorArea: 88.035 m2; GrossCeilingArea: 88.035 m2

# IfcSpace: Area:1699556
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 02; 02.07.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.07.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSH; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 89.82 m2; NetFloorArea: 89.82 m2; GrossCeilingArea: 89.82 m2

# IfcSpace: Area:1699557
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 02; 02.07.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.07.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 87.4095 m2; NetFloorArea: 87.4095 m2; GrossCeilingArea: 87.4095 m2

# IfcSpace: Area:1699559
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.08.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.08.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSH; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 83.002 m2; NetFloorArea: 83.002 m2; GrossCeilingArea: 83.002 m2

# IfcSpace: Area:1699560
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.08.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.08.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.9 m2; NetFloorArea: 90.9 m2; GrossCeilingArea: 90.9 m2

# IfcSpace: Area:1699561
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.08.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.08.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 91.3625 m2; NetFloorArea: 91.3625 m2; GrossCeilingArea: 91.3625 m2

# IfcSpace: Area:1699562
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.08.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.08.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSH; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 88.035 m2; NetFloorArea: 88.035 m2; GrossCeilingArea: 88.035 m2

# IfcSpace: Area:1699563
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.08.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.08.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSH; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 89.82 m2; NetFloorArea: 89.82 m2; GrossCeilingArea: 89.82 m2

# IfcSpace: Area:1699564
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.08.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.08.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 87.4095 m2; NetFloorArea: 87.4095 m2; GrossCeilingArea: 87.4095 m2

# IfcSpace: Area:1699649
In: 02 tweede verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1699651
In: 02 tweede verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1699653
In: 03 derde verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1699655
In: 03 derde verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1699657
In: 04 vierde verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1699659
In: 04 vierde verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1699661
In: 05 vijfde verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1699663
In: 05 vijfde verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1699665
In: 06 zesde verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1699667
In: 06 zesde verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1699669
In: 07 zevende verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1699671
In: 07 zevende verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1699673
In: 08 achtste verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1704842
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.00.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.00.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 4 kamer; Segment: VSK; WoningType: A
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 52.0794 m2; NetFloorArea: 52.0794 m2; GrossCeilingArea: 52.0794 m2

# IfcSpace: Area:1704868
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 4 kamer; Segment: VSK; WoningType: A
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 52.0794 m2; NetFloorArea: 52.0794 m2; GrossCeilingArea: 52.0794 m2

# IfcSpace: Area:1704881
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord; Programma: 4 kamer; Segment: VSK; WoningType: B
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 49.0725 m2; NetFloorArea: 49.0725 m2; GrossCeilingArea: 49.0725 m2

# IfcSpace: Area:1704883
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 4 kamer; Segment: VSK; WoningType: A
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 52.0794 m2; NetFloorArea: 52.0794 m2; GrossCeilingArea: 52.0794 m2

# IfcSpace: Area:1704885
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 4 kamer; Segment: VSK; WoningType: A
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 52.0794 m2; NetFloorArea: 52.0794 m2; GrossCeilingArea: 52.0794 m2

# IfcSpace: Area:1704889
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.01.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.01.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: C
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 97.012 m2; NetFloorArea: 97.012 m2; GrossCeilingArea: 97.012 m2

# IfcSpace: Area:1704894
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.01.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.01.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: D
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 100.965 m2; NetFloorArea: 100.965 m2; GrossCeilingArea: 100.965 m2

# IfcSpace: Area:1704896
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.01.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.01.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: C
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 97.012 m2; NetFloorArea: 97.012 m2; GrossCeilingArea: 97.012 m2

# IfcSpace: Area:1704900
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.01.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.01.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: D
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 100.965 m2; NetFloorArea: 100.965 m2; GrossCeilingArea: 100.965 m2

# IfcSpace: Area:1704902
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord; Programma: 4 kamer; Segment: VSH; WoningType: B
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 49.0725 m2; NetFloorArea: 49.0725 m2; GrossCeilingArea: 49.0725 m2

# IfcSpace: Area:1704904
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 4 kamer; Segment: VSH; WoningType: A
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 52.0794 m2; NetFloorArea: 52.0794 m2; GrossCeilingArea: 52.0794 m2

# IfcSpace: Area:1704906
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 4 kamer; Segment: VSH; WoningType: A
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 52.0794 m2; NetFloorArea: 52.0794 m2; GrossCeilingArea: 52.0794 m2

# IfcSpace: Area:1704908
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.01.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.01.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: C
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 97.012 m2; NetFloorArea: 97.012 m2; GrossCeilingArea: 97.012 m2

# IfcSpace: Area:1704910
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.01.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.01.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: D
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 100.965 m2; NetFloorArea: 100.965 m2; GrossCeilingArea: 100.965 m2

# IfcSpace: Area:1704912
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.01.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.01.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: C
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 97.012 m2; NetFloorArea: 97.012 m2; GrossCeilingArea: 97.012 m2

# IfcSpace: Area:1704938
In: 00 begane grond
LongName: Gebruiksfunctie; Group: 02; 02.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord; Programma: 4 kamer; Segment: VSH; WoningType: B
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 49.0725 m2; NetFloorArea: 49.0725 m2; GrossCeilingArea: 49.0725 m2

# IfcSpace: Area:1704940
In: 00 begane grond
LongName: Gebruiksfunctie; Group: 02; 02.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 4 kamer; Segment: VSH; WoningType: A
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 52.0794 m2; NetFloorArea: 52.0794 m2; GrossCeilingArea: 52.0794 m2

# IfcSpace: Area:1704942
In: 00 begane grond
LongName: Gebruiksfunctie; Group: 02; 02.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 4 kamer; Segment: VSH; WoningType: A
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 52.0794 m2; NetFloorArea: 52.0794 m2; GrossCeilingArea: 52.0794 m2

# IfcSpace: Area:1704954
In: 00 begane grond
LongName: Gebruiksfunctie; Group: 01; 01.00.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.00.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid; Programma: 4 kamer; Segment: VSK; WoningType: B
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 49.0725 m2; NetFloorArea: 49.0725 m2; GrossCeilingArea: 49.0725 m2

# IfcSpace: Area:1704960
In: 00 begane grond
LongName: Gebruiksfunctie; Group: 01; 01.00.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.00.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 4 kamer; Segment: VSK; WoningType: A
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 52.0794 m2; NetFloorArea: 52.0794 m2; GrossCeilingArea: 52.0794 m2

# IfcSpace: Area:1704962
In: 00 begane grond
LongName: Gebruiksfunctie; Group: 01; 01.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 4 kamer; Segment: VSK; WoningType: A
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 52.0794 m2; NetFloorArea: 52.0794 m2; GrossCeilingArea: 52.0794 m2

# IfcSpace: Area:1704964
In: 00 begane grond
LongName: Gebruiksfunctie; Group: 01; 01.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord; Programma: 4 kamer; Segment: VSK; WoningType: B
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 49.0725 m2; NetFloorArea: 49.0725 m2; GrossCeilingArea: 49.0725 m2

# IfcSpace: Area:1704966
In: 00 begane grond
LongName: Gebruiksfunctie; Group: 01; 01.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 4 kamer; Segment: VSK; WoningType: A
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 52.0794 m2; NetFloorArea: 52.0794 m2; GrossCeilingArea: 52.0794 m2

# IfcSpace: Area:1704968
In: 00 begane grond
LongName: Gebruiksfunctie; Group: 01; 01.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 4 kamer; Segment: VSK; WoningType: A
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 52.0794 m2; NetFloorArea: 52.0794 m2; GrossCeilingArea: 52.0794 m2

# IfcSpace: Area:1709311
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0288 m2; NetFloorArea: 20.0288 m2; GrossCeilingArea: 20.0288 m2

# IfcSpace: Area:1709314
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1709317
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1709320
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0387 m2; NetFloorArea: 25.0387 m2; GrossCeilingArea: 25.0387 m2

# IfcSpace: Area:1709323
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.9658 m2; NetFloorArea: 25.9658 m2; GrossCeilingArea: 25.9658 m2

# IfcSpace: Area:1709326
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.93416 m2; NetFloorArea: 5.93416 m2; GrossCeilingArea: 5.93416 m2

# IfcSpace: Area:1709329
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.01; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1709332
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.01; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0287 m2; NetFloorArea: 20.0287 m2; GrossCeilingArea: 20.0287 m2

# IfcSpace: Area:1709335
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0388 m2; NetFloorArea: 25.0388 m2; GrossCeilingArea: 25.0388 m2

# IfcSpace: Area:1709338
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1709341
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.48 m2; NetFloorArea: 6.48 m2; GrossCeilingArea: 6.48 m2

# IfcSpace: Area:1709344
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.42 m2; NetFloorArea: 25.42 m2; GrossCeilingArea: 25.42 m2

# IfcSpace: Area:1709410
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.03; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0288 m2; NetFloorArea: 20.0288 m2; GrossCeilingArea: 20.0288 m2

# IfcSpace: Area:1709412
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.03; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1709414
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1709416
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0387 m2; NetFloorArea: 25.0387 m2; GrossCeilingArea: 25.0387 m2

# IfcSpace: Area:1709418
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.9658 m2; NetFloorArea: 25.9658 m2; GrossCeilingArea: 25.9658 m2

# IfcSpace: Area:1709420
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.93416 m2; NetFloorArea: 5.93416 m2; GrossCeilingArea: 5.93416 m2

# IfcSpace: Area:1709422
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.06; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1709424
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.06; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0287 m2; NetFloorArea: 20.0287 m2; GrossCeilingArea: 20.0287 m2

# IfcSpace: Area:1709426
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0388 m2; NetFloorArea: 25.0388 m2; GrossCeilingArea: 25.0388 m2

# IfcSpace: Area:1709428
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1709430
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.48 m2; NetFloorArea: 6.48 m2; GrossCeilingArea: 6.48 m2

# IfcSpace: Area:1709432
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.42 m2; NetFloorArea: 25.42 m2; GrossCeilingArea: 25.42 m2

# IfcSpace: Area:1710063
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.02.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0288 m2; NetFloorArea: 20.0288 m2; GrossCeilingArea: 20.0288 m2

# IfcSpace: Area:1710065
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.02.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710067
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.02.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710069
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.02.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0387 m2; NetFloorArea: 25.0387 m2; GrossCeilingArea: 25.0387 m2

# IfcSpace: Area:1710071
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.02.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.9658 m2; NetFloorArea: 25.9658 m2; GrossCeilingArea: 25.9658 m2

# IfcSpace: Area:1710073
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.02.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.93416 m2; NetFloorArea: 5.93416 m2; GrossCeilingArea: 5.93416 m2

# IfcSpace: Area:1710075
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.02.01; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710077
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.02.01; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0287 m2; NetFloorArea: 20.0287 m2; GrossCeilingArea: 20.0287 m2

# IfcSpace: Area:1710079
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.02.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0388 m2; NetFloorArea: 25.0388 m2; GrossCeilingArea: 25.0388 m2

# IfcSpace: Area:1710081
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.02.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710083
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.02.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.48 m2; NetFloorArea: 6.48 m2; GrossCeilingArea: 6.48 m2

# IfcSpace: Area:1710085
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.02.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.42 m2; NetFloorArea: 25.42 m2; GrossCeilingArea: 25.42 m2

# IfcSpace: Area:1710087
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.03; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0288 m2; NetFloorArea: 20.0288 m2; GrossCeilingArea: 20.0288 m2

# IfcSpace: Area:1710089
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.03; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710091
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710093
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0387 m2; NetFloorArea: 25.0387 m2; GrossCeilingArea: 25.0387 m2

# IfcSpace: Area:1710095
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.9658 m2; NetFloorArea: 25.9658 m2; GrossCeilingArea: 25.9658 m2

# IfcSpace: Area:1710097
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.93416 m2; NetFloorArea: 5.93416 m2; GrossCeilingArea: 5.93416 m2

# IfcSpace: Area:1710099
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.06; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710101
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.06; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0287 m2; NetFloorArea: 20.0287 m2; GrossCeilingArea: 20.0287 m2

# IfcSpace: Area:1710103
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0388 m2; NetFloorArea: 25.0388 m2; GrossCeilingArea: 25.0388 m2

# IfcSpace: Area:1710105
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710107
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.48 m2; NetFloorArea: 6.48 m2; GrossCeilingArea: 6.48 m2

# IfcSpace: Area:1710109
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.42 m2; NetFloorArea: 25.42 m2; GrossCeilingArea: 25.42 m2

# IfcSpace: Area:1710114
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.03.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0288 m2; NetFloorArea: 20.0288 m2; GrossCeilingArea: 20.0288 m2

# IfcSpace: Area:1710116
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.03.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710118
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.03.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710120
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.03.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0387 m2; NetFloorArea: 25.0387 m2; GrossCeilingArea: 25.0387 m2

# IfcSpace: Area:1710122
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.03.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.9658 m2; NetFloorArea: 25.9658 m2; GrossCeilingArea: 25.9658 m2

# IfcSpace: Area:1710124
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.03.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.93416 m2; NetFloorArea: 5.93416 m2; GrossCeilingArea: 5.93416 m2

# IfcSpace: Area:1710126
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.03.01; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710128
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.03.01; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0287 m2; NetFloorArea: 20.0287 m2; GrossCeilingArea: 20.0287 m2

# IfcSpace: Area:1710130
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.03.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0388 m2; NetFloorArea: 25.0388 m2; GrossCeilingArea: 25.0388 m2

# IfcSpace: Area:1710132
In: 03 derde verdieping
