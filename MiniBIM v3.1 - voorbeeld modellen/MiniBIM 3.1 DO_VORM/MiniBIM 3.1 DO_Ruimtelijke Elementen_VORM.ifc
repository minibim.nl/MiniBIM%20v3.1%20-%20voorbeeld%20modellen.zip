Properties of the parts of a building model (IFC4), part 1 of 12

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [ContentGUID: 7b0fba1c-e461-43e6-a004-74300536da52, VersionGUID: 7265df18-267a-4dc0-a71b-dcb3ef465860, NumberOfSaves: 301], Options [Excluded Entities: IfcGroup;], CoordinateReference [CoordinateBase: Survey Point, ProjectSite: Internal]
File name: MiniBIM 3.1 DO_Ruimtelijke Elementen_VORM.ifc
Time: 2025-10-31T11:31:47+01:00
Organization: VORM Holding B.V.
Written by: IfcOpenShell 0.8.2
Made in: Bonsai 0.8.2

# IfcProject, 0000
LongName: Voorbeelmodel MiniBIM 3.1 DO-fase; Phase: PROJECTFASE

# IfcSite, Schiehaven
RefLatitude: 51, 54, 13, 78253; RefLongitude: 4, 27, 15, 99642; RefElevation: 3.5 m
Pset_SiteCommon - Reference: Project Information

# IfcBuilding, VORM huis
LongName: VORM huis
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 10; IsLandmarked: no
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; AboveGround: no
Pset_BuildingSystemCommon - Reference: Project Information

# IfcBuildingStorey: Level:Level bouwniveau (PBP) (11)
In: VORM huis
Pset_BuildingStoreyCommon - Reference: Level bouwniveau (PBP)
Name | LongName | Elevation (m) | EntranceLevel | AboveGround
-1 kelder | -1 kelder | -3.2 | no | no
00 begane grond | begane grond | 0 | yes | yes
01 eerste verdieping | 01 eerste verdieping | 3.9 | no | yes
02 tweede verdieping | 02 tweede verdieping | 6.9 | no | yes
03 derde verdieping | 03 derde verdieping | 9.9 | no | yes
04 vierde verdieping | 04 vierde verdieping | 12.9 | no | yes
05 vijfde verdieping | 05 vijfde verdieping | 15.9 | no | yes
06 zesde verdieping | 06 zesde verdieping | 18.9 | no | yes
07 zevende verdieping | 07 zevende verdieping | 21.9 | no | yes
08 achtste verdieping | 08 achtste verdieping | 24.9 | no | yes
09 negende verdieping | 09 negende verdieping | 27.9 | no | yes

# IfcSpace: 01.00.01 (13)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.00.01
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.00.01 | 01 eerste verdieping | Slaapkamer | A 1171 | 01 | 10 | Verblijfsruimte | 3 | 9.67875 | 26.6166 | 01; 01.00.01 | MiniBIM ILS - Orientatie: Noord, West
01.00.01 | 01 eerste verdieping | Slaapkamer | A 1172 | 01 | 11 | Verblijfsruimte | 3 | 6.37875 | 17.5416 | 01; 01.00.01 | MiniBIM ILS - Orientatie: Noord; Qto_SpaceBaseQuantities - GrossVolume: 17.5416 m3
01.00.01 | 01 eerste verdieping | Slaapkamer | A 1173 | 01 | 12 | Verblijfsruimte | 3 | 14.7 | 40.425 | 01; 01.00.01 | MiniBIM ILS - Orientatie: Noord
01.00.01 | 01 eerste verdieping | Badruimte | A 1174 | 01 | 08 | Restruimte | 3 | 4.2575 | 11.7081 | 01; 01.00.01 | Qto_SpaceBaseQuantities - GrossVolume: 11.7081 m3
01.00.01 | 01 eerste verdieping | Schacht | A 1175 | 01 | 09 | Restruimte | 3 | 0.2 | 0.55 | 01; 01.00.01
01.00.01 | 01 eerste verdieping | Overloop | A 1176 | 01 | 07 | Restruimte | 3 | 5.915 | 16.2662 | 01; 01.00.01
01.00.01 | 00 begane grond | Woonkamer-keuken | A 1228 | 01 | 02 | Verblijfsruimte | 3.9 | 30.025 | 109.829 | 01; 01.00.01 | MiniBIM ILS - Orientatie: Noord, West
01.00.01 | 00 begane grond | Entree | A 1234 | 01 | 01 | Restruimte | 3.9 | 2.475 | 9.03375 | 01; 01.00.01 | MiniBIM ILS - Orientatie: Noord; Qto_SpaceBaseQuantities - GrossVolume: 9.03375 m3
01.00.01 | 00 begane grond | Bergruimte | A 1240 | 01 | 03 | Restruimte | 3.9 | 5.7525 | 21.4806 | 01; 01.00.01
01.00.01 | 00 begane grond | Hal | A 1246 | 01 | 04 | Restruimte | 3.9 | 2.0925 | 7.63762 | 01; 01.00.01
01.00.01 | 00 begane grond | Toiletruimte | A 1252 | 01 | 05 | Restruimte | 3.9 | 1.14 | 4.161 | 01; 01.00.01 | Qto_SpaceBaseQuantities - GrossVolume: 4.161 m3
01.00.01 | 00 begane grond | Schacht | A 1258 | 01 | 06 | Restruimte | 3.9 | 0.2375 | 0.916875 | 01; 01.00.01
01.00.01 | -1 kelder | Berging inpandig | A 1359 | 00 | 31 | Restruimte | 3.2 | 5.54625 | 16.3614 | 01.00.01; 00

# IfcSpace: 01.00.01 (3)
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.00.01
Group: 01; 01.00.01
Name | In | LongName | Afnemer | Bepalingsmethode | GebiedsSoort | GebiedsType | Gebruiksbestemming | Orientatie | Programma | Segment | WoningType | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.00.01 | 00 begane grond | Gebruiksfunctie | Particulier | GO | Gebruiksfunctie | Maisonette | Woonfunctie | Noord, West | 4 kamer | VSK | A | 3.9 | 43.1375
01.00.01 | 01 eerste verdieping | Gebruiksfunctie | Particulier | GO | Gebruiksfunctie | Maisonette | Woonfunctie | Noord, West | 4 kamer | VSK | A | 3 | 43.1375
01.00.01 | 00 begane grond | {$this("GebiedsSoort")} |  | NVO |  |  |  | Noord |  |  |  | 3.9 | 15.085 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Tuin

# IfcSpace: 01.00.02 (13)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.00.02
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.00.02 | 01 eerste verdieping | Slaapkamer | A 1177 | 01 | 10 | Verblijfsruimte | 3 | 9.67875 | 26.6166 | 01; 01.00.02 | MiniBIM ILS - Orientatie: Noord
01.00.02 | 01 eerste verdieping | Slaapkamer | A 1178 | 01 | 11 | Verblijfsruimte | 3 | 6.37875 | 17.5416 | 01; 01.00.02 | MiniBIM ILS - Orientatie: Noord; Qto_SpaceBaseQuantities - GrossVolume: 17.5416 m3
01.00.02 | 01 eerste verdieping | Slaapkamer | A 1179 | 01 | 12 | Verblijfsruimte | 3 | 14.7 | 40.425 | 01; 01.00.02 | MiniBIM ILS - Orientatie: Noord; Qto_SpaceBaseQuantities - GrossVolume: 40.425 m3
01.00.02 | 01 eerste verdieping | Badruimte | A 1180 | 01 | 08 | Restruimte | 3 | 4.2575 | 11.7081 | 01; 01.00.02
01.00.02 | 01 eerste verdieping | Schacht | A 1181 | 01 | 09 | Restruimte | 3 | 0.2 | 0.55 | 01; 01.00.02
01.00.02 | 01 eerste verdieping | Overloop | A 1182 | 01 | 07 | Restruimte | 3 | 5.915 | 16.2663 | 01; 01.00.02 | Qto_SpaceBaseQuantities - GrossVolume: 16.2663 m3
01.00.02 | 00 begane grond | Woonkamer-keuken | A 1229 | 01 | 02 | Verblijfsruimte | 3.9 | 30.025 | 109.829 | 01; 01.00.02 | MiniBIM ILS - Orientatie: Noord
01.00.02 | 00 begane grond | Entree | A 1235 | 01 | 01 | Restruimte | 3.9 | 2.475 | 9.03375 | 01; 01.00.02 | MiniBIM ILS - Orientatie: Noord; Qto_SpaceBaseQuantities - GrossVolume: 9.03375 m3
01.00.02 | 00 begane grond | Bergruimte | A 1241 | 01 | 03 | Restruimte | 3.9 | 5.7525 | 21.4806 | 01; 01.00.02
01.00.02 | 00 begane grond | Hal | A 1247 | 01 | 04 | Restruimte | 3.9 | 2.0925 | 7.63762 | 01; 01.00.02
01.00.02 | 00 begane grond | Toiletruimte | A 1253 | 01 | 05 | Restruimte | 3.9 | 1.14 | 4.161 | 01; 01.00.02 | Qto_SpaceBaseQuantities - GrossVolume: 4.161 m3
01.00.02 | 00 begane grond | Schacht | A 1259 | 01 | 06 | Restruimte | 3.9 | 0.2375 | 0.916875 | 01; 01.00.02
01.00.02 | -1 kelder | Berging inpandig | A 1361 | 00 | 32 | Restruimte | 3.2 | 5.54625 | 16.3614 | 01.00.02; 00

# IfcSpace: 01.00.02 (3)
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.00.02; Orientatie: Noord
Group: 01; 01.00.02
Name | In | LongName | Afnemer | Bepalingsmethode | GebiedsSoort | GebiedsType | Gebruiksbestemming | Programma | Segment | WoningType | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.00.02 | 00 begane grond | Gebruiksfunctie | Particulier | GO | Gebruiksfunctie | Maisonette | Woonfunctie | 4 kamer | VSK | B | 3.9 | 43.1375
01.00.02 | 01 eerste verdieping | Gebruiksfunctie | Particulier | GO | Gebruiksfunctie | Maisonette | Woonfunctie | 4 kamer | VSK | B | 3 | 43.1375
01.00.02 | 00 begane grond | {$this("GebiedsSoort")} |  | NVO |  |  |  |  |  |  | 3.9 | 14.49 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Tuin

# IfcSpace: 01.00.03 (13)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.00.03
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3) | Group
01.00.03 | 01 eerste verdieping | Slaapkamer | A 1183 | 01 | 10 | Verblijfsruimte | 3 | 9.67875 | 26.6166 | 26.6166 | 01; 01.00.03 | MiniBIM ILS - Orientatie: Noord
01.00.03 | 01 eerste verdieping | Slaapkamer | A 1184 | 01 | 11 | Verblijfsruimte | 3 | 6.37875 | 17.5416 | 17.5416 | 01; 01.00.03 | MiniBIM ILS - Orientatie: Noord
01.00.03 | 01 eerste verdieping | Slaapkamer | A 1185 | 01 | 12 | Verblijfsruimte | 3 | 14.7 |  | 40.425 | 01; 01.00.03 | MiniBIM ILS - Orientatie: Noord, Oost
01.00.03 | 01 eerste verdieping | Badruimte | A 1186 | 01 | 08 | Restruimte | 3 | 4.2575 | 11.7081 | 11.7081 | 01; 01.00.03
01.00.03 | 01 eerste verdieping | Schacht | A 1187 | 01 | 09 | Restruimte | 3 | 0.2 | 0.55 | 0.55 | 01; 01.00.03
01.00.03 | 01 eerste verdieping | Overloop | A 1188 | 01 | 07 | Restruimte | 3 | 5.915 | 16.2663 | 16.2663 | 01; 01.00.03
01.00.03 | 00 begane grond | Woonkamer-keuken | A 1230 | 01 | 02 | Verblijfsruimte | 3.9 | 30.025 |  | 109.829 | 01; 01.00.03 | MiniBIM ILS - Orientatie: Noord, Oost
01.00.03 | 00 begane grond | Entree | A 1236 | 01 | 01 | Restruimte | 3.9 | 2.475 | 9.03375 | 9.03375 | 01; 01.00.03 | MiniBIM ILS - Orientatie: Noord
01.00.03 | 00 begane grond | Bergruimte | A 1242 | 01 | 03 | Restruimte | 3.9 | 5.7525 |  | 21.4806 | 01; 01.00.03
01.00.03 | 00 begane grond | Hal | A 1248 | 01 | 04 | Restruimte | 3.9 | 2.0925 |  | 7.63762 | 01; 01.00.03
01.00.03 | 00 begane grond | Toiletruimte | A 1254 | 01 | 05 | Restruimte | 3.9 | 1.14 | 4.161 | 4.161 | 01; 01.00.03
01.00.03 | 00 begane grond | Schacht | A 1260 | 01 | 06 | Restruimte | 3.9 | 0.2375 |  | 0.916875 | 01; 01.00.03
01.00.03 | -1 kelder | Berging inpandig | A 1363 | 00 | 33 | Restruimte | 3.2 | 5.54625 |  | 16.3614 | 01.00.03; 00

# IfcSpace: 01.00.03 (3)
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.00.03
Group: 01; 01.00.03
Name | In | LongName | Afnemer | Bepalingsmethode | GebiedsSoort | GebiedsType | Gebruiksbestemming | Orientatie | Programma | Segment | WoningType | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.00.03 | 00 begane grond | Gebruiksfunctie | Particulier | GO | Gebruiksfunctie | Maisonette | Woonfunctie | Noord, Oost | 4 kamer | VSK | A | 3.9 | 43.1375
01.00.03 | 01 eerste verdieping | Gebruiksfunctie | Particulier | GO | Gebruiksfunctie | Maisonette | Woonfunctie | Noord, Oost | 4 kamer | VSK | A | 3 | 43.1375
01.00.03 | 00 begane grond | {$this("GebiedsSoort")} |  | NVO |  |  |  | Noord |  |  |  | 3.9 | 15.085 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Tuin

# IfcSpace: 01.00.04 (13)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.00.04
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3) | Group
01.00.04 | 01 eerste verdieping | Slaapkamer | A 1165 | 01 | 10 | Verblijfsruimte | 3 | 9.67875 | 26.6166 | 26.6166 | 01; 01.00.04 | MiniBIM ILS - Orientatie: Zuid
01.00.04 | 01 eerste verdieping | Slaapkamer | A 1166 | 01 | 11 | Verblijfsruimte | 3 | 6.37875 |  | 17.5416 | 01; 01.00.04 | MiniBIM ILS - Orientatie: Zuid
01.00.04 | 01 eerste verdieping | Slaapkamer | A 1167 | 01 | 12 | Verblijfsruimte | 3 | 14.7 | 40.425 | 40.425 | 01; 01.00.04 | MiniBIM ILS - Orientatie: Zuid, Oost
01.00.04 | 01 eerste verdieping | Badruimte | A 1168 | 01 | 08 | Restruimte | 3 | 4.2575 | 11.7081 | 11.7081 | 01; 01.00.04
01.00.04 | 01 eerste verdieping | Schacht | A 1169 | 01 | 09 | Restruimte | 3 | 0.2 | 0.55 | 0.55 | 01; 01.00.04
01.00.04 | 01 eerste verdieping | Overloop | A 1170 | 01 | 07 | Restruimte | 3 | 5.915 | 16.2662 | 16.2662 | 01; 01.00.04
01.00.04 | 00 begane grond | Woonkamer-keuken | A 1227 | 01 | 02 | Verblijfsruimte | 3.9 | 30.025 |  | 109.829 | 01; 01.00.04 | MiniBIM ILS - Orientatie: Zuid
01.00.04 | 00 begane grond | Entree | A 1233 | 01 | 01 | Restruimte | 3.9 | 2.475 | 9.03375 | 9.03375 | 01; 01.00.04 | MiniBIM ILS - Orientatie: Zuid
01.00.04 | 00 begane grond | Bergruimte | A 1239 | 01 | 03 | Restruimte | 3.9 | 5.7525 |  | 21.4806 | 01; 01.00.04
01.00.04 | 00 begane grond | Hal | A 1245 | 01 | 04 | Restruimte | 3.9 | 2.0925 |  | 7.63762 | 01; 01.00.04
01.00.04 | 00 begane grond | Toiletruimte | A 1251 | 01 | 05 | Restruimte | 3.9 | 1.14 | 4.161 | 4.161 | 01; 01.00.04
01.00.04 | 00 begane grond | Schacht | A 1257 | 01 | 06 | Restruimte | 3.9 | 0.2375 |  | 0.916875 | 01; 01.00.04
01.00.04 | -1 kelder | Berging inpandig | A 1365 | 00 | 34 | Restruimte | 3.2 | 5.54625 |  | 16.3614 | 01.00.04; 00

# IfcSpace: 01.00.04 (3)
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.00.04
Group: 01; 01.00.04
Name | In | LongName | Afnemer | Bepalingsmethode | GebiedsSoort | GebiedsType | Gebruiksbestemming | Orientatie | Programma | Segment | WoningType | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.00.04 | 00 begane grond | Gebruiksfunctie | Particulier | GO | Gebruiksfunctie | Maisonette | Woonfunctie | Zuid, Oost | 4 kamer | VSK | A | 3.9 | 43.1375
01.00.04 | 01 eerste verdieping | Gebruiksfunctie | Particulier | GO | Gebruiksfunctie | Maisonette | Woonfunctie | Zuid, Oost | 4 kamer | VSK | A | 3 | 43.1375
01.00.04 | 00 begane grond | {$this("GebiedsSoort")} |  | NVO |  |  |  | Zuid |  |  |  | 3.9 | 15.085 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Tuin

# IfcSpace: 01.00.05 (13)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.00.05
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.00.05 | 01 eerste verdieping | Slaapkamer | A 1159 | 01 | 10 | Verblijfsruimte | 3 | 9.67875 | 26.6166 | 01; 01.00.05 | MiniBIM ILS - Orientatie: Zuid
01.00.05 | 01 eerste verdieping | Slaapkamer | A 1160 | 01 | 11 | Verblijfsruimte | 3 | 6.37875 | 17.5416 | 01; 01.00.05 | MiniBIM ILS - Orientatie: Zuid
01.00.05 | 01 eerste verdieping | Slaapkamer | A 1161 | 01 | 12 | Verblijfsruimte | 3 | 14.7 | 40.425 | 01; 01.00.05 | MiniBIM ILS - Orientatie: Zuid; Qto_SpaceBaseQuantities - GrossVolume: 40.425 m3
01.00.05 | 01 eerste verdieping | Badruimte | A 1162 | 01 | 08 | Restruimte | 3 | 4.2575 | 11.7081 | 01; 01.00.05
01.00.05 | 01 eerste verdieping | Schacht | A 1163 | 01 | 09 | Restruimte | 3 | 0.2 | 0.55 | 01; 01.00.05
01.00.05 | 01 eerste verdieping | Overloop | A 1164 | 01 | 07 | Restruimte | 3 | 5.915 | 16.2663 | 01; 01.00.05 | Qto_SpaceBaseQuantities - GrossVolume: 16.2663 m3
01.00.05 | 00 begane grond | Woonkamer-keuken | A 1226 | 01 | 02 | Verblijfsruimte | 3.9 | 30.025 | 109.591 | 01; 01.00.05 | MiniBIM ILS - Orientatie: Zuid; Qto_SpaceBaseQuantities - GrossVolume: 109.591 m3
01.00.05 | 00 begane grond | Entree | A 1232 | 01 | 01 | Restruimte | 3.9 | 2.475 | 9.03375 | 01; 01.00.05 | MiniBIM ILS - Orientatie: Zuid; Qto_SpaceBaseQuantities - GrossVolume: 9.03375 m3
01.00.05 | 00 begane grond | Bergruimte | A 1238 | 01 | 03 | Restruimte | 3.9 | 5.7525 | 20.9966 | 01; 01.00.05
01.00.05 | 00 begane grond | Hal | A 1244 | 01 | 04 | Restruimte | 3.9 | 2.0925 | 7.63762 | 01; 01.00.05
01.00.05 | 00 begane grond | Toiletruimte | A 1250 | 01 | 05 | Restruimte | 3.9 | 1.14 | 4.161 | 01; 01.00.05 | Qto_SpaceBaseQuantities - GrossVolume: 4.161 m3
01.00.05 | 00 begane grond | Schacht | A 1256 | 01 | 06 | Restruimte | 3.9 | 0.2375 | 0.916875 | 01; 01.00.05
01.00.05 | -1 kelder | Berging inpandig | A 1367 | 00 | 35 | Restruimte | 3.2 | 5.54625 | 16.3614 | 01.00.05; 00

# IfcSpace: 01.00.05 (3)
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.00.05; Orientatie: Zuid
Group: 01; 01.00.05
Name | In | LongName | Afnemer | Bepalingsmethode | GebiedsSoort | GebiedsType | Gebruiksbestemming | Programma | Segment | WoningType | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.00.05 | 00 begane grond | Gebruiksfunctie | Particulier | GO | Gebruiksfunctie | Maisonette | Woonfunctie | 4 kamer | VSK | B | 3.9 | 43.1375
01.00.05 | 01 eerste verdieping | Gebruiksfunctie | Particulier | GO | Gebruiksfunctie | Maisonette | Woonfunctie | 4 kamer | VSK | B | 3 | 43.1375
01.00.05 | 00 begane grond | {$this("GebiedsSoort")} |  | NVO |  |  |  |  |  |  | 3.9 | 14.49 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Tuin

# IfcSpace: 01.00.06 (13)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.00.06
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.00.06 | 01 eerste verdieping | Slaapkamer | A 1153 | 01 | 10 | Verblijfsruimte | 3 | 9.67875 | 26.6166 | 01; 01.00.06 | MiniBIM ILS - Orientatie: Zuid, West
01.00.06 | 01 eerste verdieping | Slaapkamer | A 1154 | 01 | 11 | Verblijfsruimte | 3 | 6.37875 | 17.5416 | 01; 01.00.06 | MiniBIM ILS - Orientatie: Zuid
01.00.06 | 01 eerste verdieping | Slaapkamer | A 1155 | 01 | 12 | Verblijfsruimte | 3 | 14.7 | 40.425 | 01; 01.00.06 | MiniBIM ILS - Orientatie: Zuid
01.00.06 | 01 eerste verdieping | Badruimte | A 1156 | 01 | 08 | Restruimte | 3 | 4.2575 | 11.7081 | 01; 01.00.06
01.00.06 | 01 eerste verdieping | Schacht | A 1157 | 01 | 09 | Restruimte | 3 | 0.2 | 0.55 | 01; 01.00.06
01.00.06 | 01 eerste verdieping | Overloop | A 1158 | 01 | 07 | Restruimte | 3 | 5.915 | 16.2662 | 01; 01.00.06
01.00.06 | 00 begane grond | Woonkamer-keuken | A 1225 | 01 | 02 | Verblijfsruimte | 3.9 | 30.025 | 109.829 | 01; 01.00.06 | MiniBIM ILS - Orientatie: Zuid
01.00.06 | 00 begane grond | Entree | A 1231 | 01 | 01 | Restruimte | 3.9 | 2.475 | 9.03375 | 01; 01.00.06 | MiniBIM ILS - Orientatie: Zuid; Qto_SpaceBaseQuantities - GrossVolume: 9.03375 m3
01.00.06 | 00 begane grond | Bergruimte | A 1237 | 01 | 03 | Restruimte | 3.9 | 5.7525 | 21.4806 | 01; 01.00.06
01.00.06 | 00 begane grond | Hal | A 1243 | 01 | 04 | Restruimte | 3.9 | 2.0925 | 7.63762 | 01; 01.00.06
01.00.06 | 00 begane grond | Toiletruimte | A 1249 | 01 | 05 | Restruimte | 3.9 | 1.14 | 4.161 | 01; 01.00.06 | Qto_SpaceBaseQuantities - GrossVolume: 4.161 m3
01.00.06 | 00 begane grond | Schacht | A 1255 | 01 | 06 | Restruimte | 3.9 | 0.2375 | 0.916875 | 01; 01.00.06
01.00.06 | -1 kelder | Berging inpandig | A 1369 | 00 | 36 | Restruimte | 3.2 | 5.54625 | 16.3614 | 01.00.06; 00

# IfcSpace: 01.00.06 (3)
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.00.06
Group: 01; 01.00.06
Name | In | LongName | Afnemer | Bepalingsmethode | GebiedsSoort | GebiedsType | Gebruiksbestemming | Orientatie | Programma | Segment | WoningType | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.00.06 | 00 begane grond | Gebruiksfunctie | Particulier | GO | Gebruiksfunctie | Maisonette | Woonfunctie | Zuid, West | 4 kamer | VSK | A | 3.9 | 43.1375
01.00.06 | 01 eerste verdieping | Gebruiksfunctie | Particulier | GO | Gebruiksfunctie | Maisonette | Woonfunctie | Zuid, West | 4 kamer | VSK | A | 3 | 43.1375
01.00.06 | 00 begane grond | {$this("GebiedsSoort")} |  | NVO |  |  |  | Zuid |  |  |  | 3.9 | 15.085 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Tuin

# IfcSpace: 01.01.01 (10)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.01.01
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.01.01 | 01 eerste verdieping | Woonkamer-keuken | A 844 | 01 | 07 | Verblijfsruimte | 3 | 42.365 | 116.504 | 01; 01.01.01 | MiniBIM ILS - Orientatie: Oost
01.01.01 | 01 eerste verdieping | Bergruimte | A 845 | 01 | 08 | Restruimte | 3 | 4.675 | 12.9163 | 01; 01.01.01
01.01.01 | 01 eerste verdieping | Schacht | A 846 | 01 | 09 | Restruimte | 3 | 0.105 | 0.310625 | 01; 01.01.01
01.01.01 | 01 eerste verdieping | Slaapkamer | A 847 | 01 | 06 | Verblijfsruimte | 3 | 7.125 | 19.5938 | 01; 01.01.01 | MiniBIM ILS - Orientatie: Oost
01.01.01 | 01 eerste verdieping | Slaapkamer | A 848 | 01 | 05 | Verblijfsruimte | 3 | 13.8775 | 38.1631 | 01; 01.01.01 | MiniBIM ILS - Orientatie: Oost; Qto_SpaceBaseQuantities - GrossVolume: 38.1631 m3
01.01.01 | 01 eerste verdieping | Toiletruimte | A 849 | 01 | 02 | Restruimte | 3 | 1.33 | 3.6575 | 01; 01.01.01
01.01.01 | 01 eerste verdieping | Schacht | A 850 | 01 | 03 | Restruimte | 3 | 0.42 | 1.155 | 01; 01.01.01
01.01.01 | 01 eerste verdieping | Badruimte | A 851 | 01 | 04 | Restruimte | 3 | 4.42 | 12.155 | 01; 01.01.01 | Qto_SpaceBaseQuantities - GrossVolume: 12.155 m3
01.01.01 | 01 eerste verdieping | Entree | A 852 | 01 | 01 | Restruimte | 3 | 9.78575 | 26.9108 | 01; 01.01.01 | Qto_SpaceBaseQuantities - GrossVolume: 26.9108 m3
01.01.01 | -1 kelder | Berging inpandig | A 1364 | 00 | 28 | Restruimte | 3.2 | 4.70375 | 13.8761 | 01.01.01; 00

# IfcSpace: 01.01.01 (2)
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.01.01; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.01.01
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.01.01 | Gebruiksfunctie | GO | 86.6633 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: C
01.01.01 | Area | NVO | 4.8 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Loggia

# IfcSpace: 01.01.02 (12)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.01.02
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.01.02 | 01 eerste verdieping | Woonkamer-keuken | A 821 | 01 | 04 | Verblijfsruimte | 3 | 42.365 | 116.504 | 01; 01.01.02 | MiniBIM ILS - Orientatie: West
01.01.02 | 01 eerste verdieping | Slaapkamer | A 822 | 01 | 05 | Verblijfsruimte | 3 | 7.125 | 19.5938 | 01; 01.01.02 | MiniBIM ILS - Orientatie: West
01.01.02 | 01 eerste verdieping | Slaapkamer | A 823 | 01 | 06 | Verblijfsruimte | 3 | 13.8775 | 38.1631 | 01; 01.01.02 | MiniBIM ILS - Orientatie: West; Qto_SpaceBaseQuantities - GrossVolume: 38.1631 m3
01.01.02 | 01 eerste verdieping | Badruimte | A 824 | 01 | 07 | Restruimte | 3 | 4.16 | 11.44 | 01; 01.01.02
01.01.02 | 01 eerste verdieping | Bergruimte | A 825 | 01 | 09 | Restruimte | 3 | 1.78875 | 4.91906 | 01; 01.01.02
01.01.02 | 01 eerste verdieping | Toiletruimte | A 826 | 01 | 10 | Restruimte | 3 | 1.1875 | 3.26562 | 01; 01.01.02
01.01.02 | 01 eerste verdieping | Schacht | A 827 | 01 | 11 | Restruimte | 3 | 0.34375 | 1.03125 | 01; 01.01.02 | Qto_SpaceBaseQuantities - GrossVolume: 1.03125 m3
01.01.02 | 01 eerste verdieping | Entree | A 828 | 01 | 01 | Restruimte | 3 | 9.7225 | 26.7369 | 01; 01.01.02
01.01.02 | 01 eerste verdieping | Schacht | A 830 | 01 | 03 | Restruimte | 3 | 0.105 | 0.315 | 01; 01.01.02 | Qto_SpaceBaseQuantities - GrossVolume: 0.315 m3
01.01.02 | 01 eerste verdieping | Bergruimte | A 831 | 01 | 08 | Restruimte | 3 | 2.03 | 5.5825 | 01; 01.01.02
01.01.02 | 01 eerste verdieping | Bergruimte | A 832 | 01 | 02 | Restruimte | 3 | 4.675 | 12.8863 | 01; 01.01.02
01.01.02 | -1 kelder | Berging inpandig | A 1360 | 00 | 27 | Restruimte | 3.2 | 4.70375 | 13.8761 | 01.01.02; 00

# IfcSpace: 01.01.02 (2)
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.01.02; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.01.02
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.01.02 | Gebruiksfunctie | GO | 90.3375 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: D
01.01.02 | Area | NVO | 4.8 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Loggia

# IfcSpace: 01.01.03 (12)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.01.03
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.01.03 | 01 eerste verdieping | Woonkamer-keuken | A 833 | 01 | 04 | Verblijfsruimte | 3 | 42.365 | 116.504 | 01; 01.01.03 | MiniBIM ILS - Orientatie: West
01.01.03 | 01 eerste verdieping | Slaapkamer | A 834 | 01 | 05 | Verblijfsruimte | 3 | 7.125 | 19.5938 | 01; 01.01.03 | MiniBIM ILS - Orientatie: West
01.01.03 | 01 eerste verdieping | Slaapkamer | A 835 | 01 | 06 | Verblijfsruimte | 3 | 13.8775 | 38.1631 | 01; 01.01.03 | MiniBIM ILS - Orientatie: West; Qto_SpaceBaseQuantities - GrossVolume: 38.1631 m3
01.01.03 | 01 eerste verdieping | Badruimte | A 836 | 01 | 07 | Restruimte | 3 | 4.16 | 11.44 | 01; 01.01.03
01.01.03 | 01 eerste verdieping | Bergruimte | A 837 | 01 | 09 | Restruimte | 3 | 1.78875 | 5.01281 | 01; 01.01.03
01.01.03 | 01 eerste verdieping | Toiletruimte | A 838 | 01 | 10 | Restruimte | 3 | 1.1875 | 3.26562 | 01; 01.01.03
01.01.03 | 01 eerste verdieping | Schacht | A 839 | 01 | 11 | Restruimte | 3 | 0.34375 | 0.945313 | 01; 01.01.03 | Qto_SpaceBaseQuantities - GrossVolume: 0.945313 m3
01.01.03 | 01 eerste verdieping | Entree | A 840 | 01 | 01 | Restruimte | 3 | 9.7225 | 26.7369 | 01; 01.01.03
01.01.03 | 01 eerste verdieping | Schacht | A 841 | 01 | 03 | Restruimte | 3 | 0.105 | 0.28875 | 01; 01.01.03 | Qto_SpaceBaseQuantities - GrossVolume: 0.28875 m3
01.01.03 | 01 eerste verdieping | Bergruimte | A 842 | 01 | 08 | Restruimte | 3 | 2.03 | 5.5825 | 01; 01.01.03
01.01.03 | 01 eerste verdieping | Bergruimte | A 843 | 01 | 02 | Restruimte | 3 | 4.675 | 12.8563 | 01; 01.01.03
01.01.03 | -1 kelder | Berging inpandig | A 1357 | 00 | 26 | Restruimte | 3.2 | 4.70375 | 13.8761 | 01.01.03; 00 | Qto_SpaceBaseQuantities - GrossVolume: 13.8761 m3

# IfcSpace: 01.01.03 (2)
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.01.03; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.01.03
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.01.03 | Gebruiksfunctie | GO | 90.3375 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: D
01.01.03 | Area | NVO | 4.8 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Loggia

# IfcSpace: 01.01.04 (11)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.01.04
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.01.04 | 01 eerste verdieping | Woonkamer-keuken | A 853 | 01 | 08 | Verblijfsruimte | 3 | 42.365 | 116.504 | 01; 01.01.04 | MiniBIM ILS - Orientatie: Oost
01.01.04 | 01 eerste verdieping | Bergruimte | A 854 | 01 | 09 | Restruimte | 3 | 4.675 | 12.8929 | 01; 01.01.04
01.01.04 | 01 eerste verdieping | Slaapkamer | A 855 | 01 | 07 | Verblijfsruimte | 3 | 7.125 | 19.5938 | 01; 01.01.04 | MiniBIM ILS - Orientatie: Oost
01.01.04 | 01 eerste verdieping | Slaapkamer | A 856 | 01 | 06 | Verblijfsruimte | 3 | 13.8775 | 38.1631 | 01; 01.01.04 | MiniBIM ILS - Orientatie: Oost; Qto_SpaceBaseQuantities - GrossVolume: 38.1631 m3
01.01.04 | 01 eerste verdieping | Toiletruimte | A 857 | 01 | 02 | Restruimte | 3 | 1.33 | 3.6575 | 01; 01.01.04
01.01.04 | 01 eerste verdieping | Schacht | A 858 | 01 | 03 | Restruimte | 3 | 0.42 | 1.155 | 01; 01.01.04
01.01.04 | 01 eerste verdieping | Badruimte | A 859 | 01 | 04 | Restruimte | 3 | 3.97 | 10.955 | 01; 01.01.04
01.01.04 | 01 eerste verdieping | Entree | A 860 | 01 | 01 | Restruimte | 3 | 9.78575 | 26.9108 | 01; 01.01.04 | Qto_SpaceBaseQuantities - GrossVolume: 26.9108 m3
01.01.04 | 01 eerste verdieping | Schacht | A 900 | 01 | 05 | Restruimte | 3 | 0.32 | 0.94 | 01; 01.01.04
01.01.04 | 01 eerste verdieping | Schacht | A 901 | 01 | 10 | Restruimte | 3 | 0.105 | 0.301087 | 01; 01.01.04
01.01.04 | -1 kelder | Berging inpandig | A 1379 | 00 | 12 | Restruimte | 3.2 | 5.54837 | 16.3677 | 01.01.04; 00

# IfcSpace: 01.01.04 (2)
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.01.04; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.01.04
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.01.04 | Gebruiksfunctie | GO | 86.6633 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: C
01.01.04 | Area | NVO | 4.8 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Loggia

# IfcSpace: 01.02.01 (9)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.02.01
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.02.01 | 02 tweede verdieping | Woonkamer-keuken | A 191 | 01 | 04 | Verblijfsruimte | 3 | 26.6437 | 73.2703 | 01; 01.02.01 | MiniBIM ILS - Orientatie: Zuid, Oost
01.02.01 | 02 tweede verdieping | Slaapkamer | A 192 | 01 | 03 | Verblijfsruimte | 3 | 9.37125 | 25.7709 | 01; 01.02.01 | MiniBIM ILS - Orientatie: Zuid; Qto_SpaceBaseQuantities - GrossVolume: 25.7709 m3
01.02.01 | 02 tweede verdieping | Slaapkamer | A 193 | 01 | 03 | Verblijfsruimte | 3 | 13.975 | 38.4313 | 01; 01.02.01 | MiniBIM ILS - Orientatie: Oost
01.02.01 | 02 tweede verdieping | Entree | A 194 | 01 | 01 | Restruimte | 3 | 10.7332 | 29.5164 | 01; 01.02.01
01.02.01 | 02 tweede verdieping | Bergruimte | A 195 | 01 | 06 | Restruimte | 3 | 2.0925 | 5.75437 | 01; 01.02.01
01.02.01 | 02 tweede verdieping | Toiletruimte | A 196 | 01 | 07 | Restruimte | 3 | 1.1875 | 3.26563 | 01; 01.02.01 | Qto_SpaceBaseQuantities - GrossVolume: 3.26563 m3
01.02.01 | 02 tweede verdieping | Badruimte | A 197 | 01 | 05 | Restruimte | 3 | 4.16 | 11.44 | 01; 01.02.01 | Qto_SpaceBaseQuantities - GrossVolume: 11.44 m3
01.02.01 | 02 tweede verdieping | Schacht | A 198 | 01 | 08 | Restruimte | 3 | 0.375 | 1.125 | 01; 01.02.01 | Qto_SpaceBaseQuantities - GrossVolume: 1.125 m3
01.02.01 | -1 kelder | Berging inpandig | A 1377 | 00 | 11 | Restruimte | 3.2 | 5.54838 | 16.3677 | 01.02.01; 00

# IfcSpace: 01.02.01 (3)
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.02.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.02.01
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | BuitenruimteSoort | BuitenruimteType
01.02.01 | Gebruiksfunctie | GO | Zuid, Oost | 70.6182 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: G
01.02.01 | Area | NVO | Oost | 6.27 | Overdekt | Balkon
01.02.01 | Area | NVO | Zuid, Oost | 46.2126 | Niet-overdekt | Dakterras

# IfcSpace: 01.02.02 (9)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.02.02
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.02.02 | 02 tweede verdieping | Woonkamer-keuken | A 79 | 01 | 04 | Verblijfsruimte | 3 | 30.9787 | 85.1916 | 01; 01.02.02 | MiniBIM ILS - Orientatie: Zuid, West
01.02.02 | 02 tweede verdieping | Slaapkamer | A 80 | 01 | 03 | Verblijfsruimte | 3 | 7.9375 | 21.8281 | 01; 01.02.02 | MiniBIM ILS - Orientatie: Zuid
01.02.02 | 02 tweede verdieping | Slaapkamer | A 81 | 01 | 02 | Verblijfsruimte | 3 | 14.1287 | 38.8541 | 01; 01.02.02 | MiniBIM ILS - Orientatie: Zuid
01.02.02 | 02 tweede verdieping | Badruimte | A 82 | 01 | 05 | Restruimte | 3 | 5.5 | 15.125 | 01; 01.02.02
01.02.02 | 02 tweede verdieping | Bergruimte | A 83 | 01 | 06 | Restruimte | 3 | 4.5025 | 12.3819 | 01; 01.02.02 | Qto_SpaceBaseQuantities - GrossVolume: 12.3819 m3
01.02.02 | 02 tweede verdieping | Toiletruimte | A 84 | 01 | 07 | Restruimte | 3 | 1.1875 | 3.26563 | 01; 01.02.02 | Qto_SpaceBaseQuantities - GrossVolume: 3.26563 m3
01.02.02 | 02 tweede verdieping | Schacht | A 85 | 01 | 08 | Restruimte | 3 | 0.255 | 0.765 | 01; 01.02.02 | Qto_SpaceBaseQuantities - GrossVolume: 0.765 m3
01.02.02 | 02 tweede verdieping | Entree | A 86 | 01 | 01 | Restruimte | 3 | 11.365 | 31.2538 | 01; 01.02.02 | Qto_SpaceBaseQuantities - GrossVolume: 31.2538 m3
01.02.02 | -1 kelder | Berging inpandig | A 1381 | 00 | 10 | Restruimte | 3.2 | 5.54838 | 16.3677 | 01.02.02; 00

# IfcSpace: 01.02.02 (3)
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.02.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.02.02
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | BuitenruimteSoort | BuitenruimteType
01.02.02 | Gebruiksfunctie | GO | Zuid, West | 78.3725 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: H
01.02.02 | Area | NVO | West | 6.27 | Overdekt | Balkon
01.02.02 | Area | NVO | Zuid, West | 53.1326 | Niet-overdekt | Dakterras

# IfcSpace: 01.02.03 (12)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.02.03
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.02.03 | 02 tweede verdieping | Woonkamer-keuken | A 303 | 01 | 02 | Verblijfsruimte | 3 | 31.9 | 87.725 | 01; 01.02.03 | MiniBIM ILS - Orientatie: West
01.02.03 | 02 tweede verdieping | Badruimte | A 304 | 01 | 05 | Restruimte | 3 | 4.16 | 11.44 | 01; 01.02.03
01.02.03 | 02 tweede verdieping | Slaapkamer | A 305 | 01 | 03 | Verblijfsruimte | 3 | 11.1475 | 30.6556 | 01; 01.02.03 | MiniBIM ILS - Orientatie: West
01.02.03 | 02 tweede verdieping | Slaapkamer | A 306 | 01 | 04 | Verblijfsruimte | 3 | 13.65 | 37.5375 | 01; 01.02.03 | MiniBIM ILS - Orientatie: West
01.02.03 | 02 tweede verdieping | Bergruimte | A 307 | 01 | 09 | Restruimte | 3 | 1.78875 | 4.91906 | 01; 01.02.03
01.02.03 | 02 tweede verdieping | Toiletruimte | A 308 | 01 | 10 | Restruimte | 3 | 1.1875 | 3.26562 | 01; 01.02.03
01.02.03 | 02 tweede verdieping | Schacht | A 309 | 01 | 11 | Restruimte | 3 | 0.34375 | 1.03125 | 01; 01.02.03 | Qto_SpaceBaseQuantities - GrossVolume: 1.03125 m3
01.02.03 | 02 tweede verdieping | Entree | A 310 | 01 | 01 | Restruimte | 3 | 4.455 | 12.2513 | 01; 01.02.03
01.02.03 | 02 tweede verdieping | Bergruimte | A 311 | 01 | 07 | Restruimte | 3 | 2.1 | 5.775 | 01; 01.02.03
01.02.03 | 02 tweede verdieping | Bergruimte | A 312 | 01 | 06 | Restruimte | 3 | 3.15 | 8.6625 | 01; 01.02.03
01.02.03 | 02 tweede verdieping | Gang | A 313 | 01 | 08 | Restruimte | 3 | 4.235 | 11.6463 | 01; 01.02.03 | Qto_SpaceBaseQuantities - GrossVolume: 11.6463 m3
01.02.03 | -1 kelder | Berging inpandig | A 1383 | 00 | 09 | Restruimte | 3.2 | 5.54838 | 16.3677 | 01.02.03; 00

# IfcSpace: 01.02.03 (2)
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.02.03; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.02.03
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.02.03 | Gebruiksfunctie | GO | 81.4275 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: I
01.02.03 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.02.04 (10)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.02.04
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.02.04 | 02 tweede verdieping | Woonkamer-keuken | A 583 | 01 | 07 | Verblijfsruimte | 3 | 26.6437 | 73.2703 | 01; 01.02.04 | MiniBIM ILS - Orientatie: Noord, West
01.02.04 | 02 tweede verdieping | Slaapkamer | A 584 | 01 | 06 | Verblijfsruimte | 3 | 13.975 | 38.4313 | 01; 01.02.04 | MiniBIM ILS - Orientatie: West
01.02.04 | 02 tweede verdieping | Slaapkamer | A 585 | 01 | 08 | Verblijfsruimte | 3 | 9.9225 | 27.2869 | 01; 01.02.04 | MiniBIM ILS - Orientatie: Noord
01.02.04 | 02 tweede verdieping | Bergruimte | A 586 | 01 | 09 | Restruimte | 3 | 4.06 | 11.165 | 01; 01.02.04 | Qto_SpaceBaseQuantities - GrossVolume: 11.165 m3
01.02.04 | 02 tweede verdieping | Badruimte | A 587 | 01 | 05 | Restruimte | 3 | 4.16 | 11.44 | 01; 01.02.04
01.02.04 | 02 tweede verdieping | Toiletruimte | A 588 | 01 | 03 | Restruimte | 3 | 1.1875 | 3.26563 | 01; 01.02.04
01.02.04 | 02 tweede verdieping | Schacht | A 589 | 01 | 04 | Restruimte | 3 | 0.375 | 1.125 | 01; 01.02.04 | Qto_SpaceBaseQuantities - GrossVolume: 1.125 m3
01.02.04 | 02 tweede verdieping | Bergruimte | A 590 | 01 | 02 | Restruimte | 3 | 1.8225 | 5.01187 | 01; 01.02.04 | Qto_SpaceBaseQuantities - GrossVolume: 5.01187 m3
01.02.04 | 02 tweede verdieping | Entree | A 591 | 01 | 01 | Restruimte | 3 | 10.8075 | 29.7206 | 01; 01.02.04
01.02.04 | -1 kelder | Berging inpandig | A 1385 | 00 | 08 | Restruimte | 3.2 | 5.54838 | 16.3677 | 01.02.04; 00

# IfcSpace: 01.02.04 (3)
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.02.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.02.04
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | BuitenruimteSoort | BuitenruimteType
01.02.04 | Gebruiksfunctie | GO | Noord, West | 75.3187 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: J
01.02.04 | Area | NVO | West | 6.27 | Overdekt | Balkon
01.02.04 | Area | NVO | Noord, West | 45.5639 | Niet-overdekt | Dakterras

# IfcSpace: 01.02.05 (9)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.02.05
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group | GrossVolume (m3)
01.02.05 | 02 tweede verdieping | Woonkamer-keuken | A 709 | 01 | 04 | Verblijfsruimte | 3 | 30.9787 | 85.1916 | 01; 01.02.05 | MiniBIM ILS - Orientatie: Noord, Oost
01.02.05 | 02 tweede verdieping | Slaapkamer | A 710 | 01 | 02 | Verblijfsruimte | 3 | 13.6525 | 37.5444 | 01; 01.02.05 | 37.5444 | MiniBIM ILS - Orientatie: Noord
01.02.05 | 02 tweede verdieping | Slaapkamer | A 711 | 01 | 03 | Verblijfsruimte | 3 | 7.9375 | 21.8281 | 01; 01.02.05 | 21.8281 | MiniBIM ILS - Orientatie: Noord
01.02.05 | 02 tweede verdieping | Badruimte | A 712 | 01 | 05 | Restruimte | 3 | 5.5 | 15.125 | 01; 01.02.05
01.02.05 | 02 tweede verdieping | Toiletruimte | A 713 | 01 | 07 | Restruimte | 3 | 1.1875 | 3.26562 | 01; 01.02.05 | 3.26562
01.02.05 | 02 tweede verdieping | Bergruimte | A 714 | 01 | 06 | Restruimte | 3 | 4.1527 | 11.4199 | 01; 01.02.05 | 11.4199
01.02.05 | 02 tweede verdieping | Schacht | A 715 | 01 | 08 | Restruimte | 3 | 0.255 | 0.765 | 01; 01.02.05 | 0.765
01.02.05 | 02 tweede verdieping | Entree | A 716 | 01 | 01 | Restruimte | 3 | 11.2207 | 30.8569 | 01; 01.02.05 | 30.8569
01.02.05 | -1 kelder | Berging inpandig | A 1387 | 00 | 07 | Restruimte | 3.2 | 5.54838 | 16.3677 | 01.02.05; 00

# IfcSpace: 01.02.05 (3)
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.02.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.02.05
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | BuitenruimteSoort | BuitenruimteType
01.02.05 | Gebruiksfunctie | GO | Noord, Oost | 77.3712 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: E
01.02.05 | Area | NVO | Oost | 6.27 | Overdekt | Balkon
01.02.05 | Area | NVO | Noord, Oost | 52.4839 | Niet-overdekt | Dakterras

# IfcSpace: 01.02.06 (10)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.02.06
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.02.06 | 02 tweede verdieping | Slaapkamer | A 457 | 01 | 05 | Verblijfsruimte | 3 | 13.65 | 37.5375 | 01; 01.02.06 | MiniBIM ILS - Orientatie: Oost
01.02.06 | 02 tweede verdieping | Slaapkamer | A 458 | 01 | 04 | Verblijfsruimte | 3 | 8.575 | 23.5813 | 01; 01.02.06 | MiniBIM ILS - Orientatie: Oost
01.02.06 | 02 tweede verdieping | Woonkamer-keuken | A 459 | 01 | 02 | Verblijfsruimte | 3 | 31.9 | 87.725 | 01; 01.02.06 | MiniBIM ILS - Orientatie: Oost
01.02.06 | 02 tweede verdieping | Badruimte | A 460 | 01 | 06 | Restruimte | 3 | 4.16 | 11.44 | 01; 01.02.06 | Qto_SpaceBaseQuantities - GrossVolume: 11.44 m3
01.02.06 | 02 tweede verdieping | Toiletruimte | A 461 | 01 | 08 | Restruimte | 3 | 1.1875 | 3.26562 | 01; 01.02.06 | Qto_SpaceBaseQuantities - GrossVolume: 3.26562 m3
01.02.06 | 02 tweede verdieping | Schacht | A 462 | 01 | 09 | Restruimte | 3 | 0.42 | 1.26 | 01; 01.02.06 | Qto_SpaceBaseQuantities - GrossVolume: 1.26 m3
01.02.06 | 02 tweede verdieping | Entree | A 463 | 01 | 01 | Restruimte | 3 | 4.62825 | 12.7277 | 01; 01.02.06 | Qto_SpaceBaseQuantities - GrossVolume: 12.7277 m3
01.02.06 | 02 tweede verdieping | Gang | A 464 | 01 | 03 | Restruimte | 3 | 5.39 | 14.8225 | 01; 01.02.06 | Qto_SpaceBaseQuantities - GrossVolume: 14.8225 m3
01.02.06 | 02 tweede verdieping | Bergruimte | A 465 | 01 | 07 | Restruimte | 3 | 4.83 | 13.2825 | 01; 01.02.06
01.02.06 | -1 kelder | Berging inpandig | A 1389 | 00 | 06 | Restruimte | 3.2 | 5.54838 | 16.3677 | 01.02.06; 00

# IfcSpace: 01.02.06 (2)
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.02.06; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.02.06
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.02.06 | Gebruiksfunctie | GO | 77.7495 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: F
01.02.06 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.03.01 (9)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.03.01
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.03.01 | 03 derde verdieping | Woonkamer-keuken | A 199 | 01 | 04 | Verblijfsruimte | 3 | 26.6437 | 73.2703 | 01; 01.03.01 | MiniBIM ILS - Orientatie: Zuid, Oost
01.03.01 | 03 derde verdieping | Slaapkamer | A 200 | 01 | 03 | Verblijfsruimte | 3 | 9.37125 | 25.7709 | 01; 01.03.01 | MiniBIM ILS - Orientatie: Zuid; Qto_SpaceBaseQuantities - GrossVolume: 25.7709 m3
01.03.01 | 03 derde verdieping | Slaapkamer | A 201 | 01 | 03 | Verblijfsruimte | 3 | 13.975 | 38.4313 | 01; 01.03.01 | MiniBIM ILS - Orientatie: Oost
01.03.01 | 03 derde verdieping | Entree | A 202 | 01 | 01 | Restruimte | 3 | 10.7332 | 29.5164 | 01; 01.03.01
01.03.01 | 03 derde verdieping | Bergruimte | A 203 | 01 | 06 | Restruimte | 3 | 2.0925 | 5.75437 | 01; 01.03.01
01.03.01 | 03 derde verdieping | Toiletruimte | A 204 | 01 | 07 | Restruimte | 3 | 1.1875 | 3.26563 | 01; 01.03.01 | Qto_SpaceBaseQuantities - GrossVolume: 3.26563 m3
01.03.01 | 03 derde verdieping | Badruimte | A 205 | 01 | 05 | Restruimte | 3 | 4.16 | 11.44 | 01; 01.03.01 | Qto_SpaceBaseQuantities - GrossVolume: 11.44 m3
01.03.01 | 03 derde verdieping | Schacht | A 206 | 01 | 08 | Restruimte | 3 | 0.375 | 1.125 | 01; 01.03.01 | Qto_SpaceBaseQuantities - GrossVolume: 1.125 m3
01.03.01 | -1 kelder | Berging inpandig | A 1394 | 00 | 05 | Restruimte | 3.2 | 5.54837 | 16.3677 | 01.03.01; 00

# IfcSpace: 01.03.01 (2)
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.03.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.03.01
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.03.01 | Gebruiksfunctie | GO | Zuid, Oost | 70.6182 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: G
01.03.01 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.03.02 (9)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.03.02
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.03.02 | 03 derde verdieping | Woonkamer-keuken | A 87 | 01 | 04 | Verblijfsruimte | 3 | 30.9787 | 85.1916 | 01; 01.03.02 | MiniBIM ILS - Orientatie: Zuid, West
01.03.02 | 03 derde verdieping | Slaapkamer | A 88 | 01 | 03 | Verblijfsruimte | 3 | 7.9375 | 21.8281 | 01; 01.03.02 | MiniBIM ILS - Orientatie: Zuid
01.03.02 | 03 derde verdieping | Slaapkamer | A 89 | 01 | 02 | Verblijfsruimte | 3 | 14.1287 | 38.8541 | 01; 01.03.02 | MiniBIM ILS - Orientatie: Zuid
01.03.02 | 03 derde verdieping | Badruimte | A 90 | 01 | 05 | Restruimte | 3 | 5.5 | 15.125 | 01; 01.03.02
01.03.02 | 03 derde verdieping | Bergruimte | A 91 | 01 | 06 | Restruimte | 3 | 4.5025 | 12.3819 | 01; 01.03.02 | Qto_SpaceBaseQuantities - GrossVolume: 12.3819 m3
01.03.02 | 03 derde verdieping | Toiletruimte | A 92 | 01 | 07 | Restruimte | 3 | 1.1875 | 3.26563 | 01; 01.03.02 | Qto_SpaceBaseQuantities - GrossVolume: 3.26563 m3
01.03.02 | 03 derde verdieping | Schacht | A 93 | 01 | 08 | Restruimte | 3 | 0.255 | 0.765 | 01; 01.03.02 | Qto_SpaceBaseQuantities - GrossVolume: 0.765 m3
01.03.02 | 03 derde verdieping | Entree | A 94 | 01 | 01 | Restruimte | 3 | 11.365 | 31.2538 | 01; 01.03.02 | Qto_SpaceBaseQuantities - GrossVolume: 31.2538 m3
01.03.02 | -1 kelder | Berging inpandig | A 1395 | 00 | 04 | Restruimte | 3.2 | 5.54837 | 16.3677 | 01.03.02; 00

# IfcSpace: 01.03.02 (2)
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.03.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.03.02
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.03.02 | Gebruiksfunctie | GO | Zuid, West | 78.3725 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: H
01.03.02 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.03.03 (12)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.03.03
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.03.03 | 03 derde verdieping | Woonkamer-keuken | A 314 | 01 | 02 | Verblijfsruimte | 3 | 31.9 | 87.725 | 01; 01.03.03 | MiniBIM ILS - Orientatie: West
01.03.03 | 03 derde verdieping | Badruimte | A 315 | 01 | 05 | Restruimte | 3 | 4.16 | 11.44 | 01; 01.03.03
01.03.03 | 03 derde verdieping | Slaapkamer | A 316 | 01 | 03 | Verblijfsruimte | 3 | 11.1475 | 30.6556 | 01; 01.03.03 | MiniBIM ILS - Orientatie: West
01.03.03 | 03 derde verdieping | Slaapkamer | A 317 | 01 | 04 | Verblijfsruimte | 3 | 13.65 | 37.5375 | 01; 01.03.03 | MiniBIM ILS - Orientatie: West
01.03.03 | 03 derde verdieping | Bergruimte | A 318 | 01 | 09 | Restruimte | 3 | 1.78875 | 4.91906 | 01; 01.03.03
01.03.03 | 03 derde verdieping | Toiletruimte | A 319 | 01 | 10 | Restruimte | 3 | 1.1875 | 3.26562 | 01; 01.03.03
01.03.03 | 03 derde verdieping | Schacht | A 320 | 01 | 11 | Restruimte | 3 | 0.34375 | 1.03125 | 01; 01.03.03 | Qto_SpaceBaseQuantities - GrossVolume: 1.03125 m3
01.03.03 | 03 derde verdieping | Entree | A 321 | 01 | 01 | Restruimte | 3 | 4.455 | 12.2513 | 01; 01.03.03
01.03.03 | 03 derde verdieping | Bergruimte | A 322 | 01 | 07 | Restruimte | 3 | 2.1 | 5.775 | 01; 01.03.03
01.03.03 | 03 derde verdieping | Bergruimte | A 323 | 01 | 06 | Restruimte | 3 | 3.15 | 8.6625 | 01; 01.03.03
01.03.03 | 03 derde verdieping | Gang | A 324 | 01 | 08 | Restruimte | 3 | 4.235 | 11.6463 | 01; 01.03.03 | Qto_SpaceBaseQuantities - GrossVolume: 11.6463 m3
01.03.03 | -1 kelder | Berging inpandig | A 1396 | 00 | 03 | Restruimte | 3.2 | 5.54837 | 16.3677 | 01.03.03; 00

# IfcSpace: 01.03.03 (2)
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.03.03; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.03.03
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.03.03 | Gebruiksfunctie | GO | 81.4275 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: I
01.03.03 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.03.04 (10)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.03.04
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.03.04 | 03 derde verdieping | Woonkamer-keuken | A 592 | 01 | 07 | Verblijfsruimte | 3 | 26.6437 | 73.2703 | 01; 01.03.04 | MiniBIM ILS - Orientatie: Noord, West
01.03.04 | 03 derde verdieping | Slaapkamer | A 593 | 01 | 06 | Verblijfsruimte | 3 | 13.975 | 38.4313 | 01; 01.03.04 | MiniBIM ILS - Orientatie: West
01.03.04 | 03 derde verdieping | Slaapkamer | A 594 | 01 | 08 | Verblijfsruimte | 3 | 9.9225 | 27.2869 | 01; 01.03.04 | MiniBIM ILS - Orientatie: Noord
01.03.04 | 03 derde verdieping | Bergruimte | A 595 | 01 | 09 | Restruimte | 3 | 4.06 | 11.165 | 01; 01.03.04 | Qto_SpaceBaseQuantities - GrossVolume: 11.165 m3
01.03.04 | 03 derde verdieping | Badruimte | A 596 | 01 | 05 | Restruimte | 3 | 4.16 | 11.44 | 01; 01.03.04
01.03.04 | 03 derde verdieping | Toiletruimte | A 597 | 01 | 03 | Restruimte | 3 | 1.1875 | 3.26563 | 01; 01.03.04
01.03.04 | 03 derde verdieping | Schacht | A 598 | 01 | 04 | Restruimte | 3 | 0.375 | 1.125 | 01; 01.03.04 | Qto_SpaceBaseQuantities - GrossVolume: 1.125 m3
01.03.04 | 03 derde verdieping | Bergruimte | A 599 | 01 | 02 | Restruimte | 3 | 1.8225 | 5.01187 | 01; 01.03.04 | Qto_SpaceBaseQuantities - GrossVolume: 5.01187 m3
01.03.04 | 03 derde verdieping | Entree | A 600 | 01 | 01 | Restruimte | 3 | 10.8075 | 29.7206 | 01; 01.03.04
01.03.04 | -1 kelder | Berging inpandig | A 1384 | 00 | 13 | Restruimte | 3.2 | 7.54375 | 24.14 | 01.03.04; 00 | Qto_SpaceBaseQuantities - GrossVolume: 24.14 m3

# IfcSpace: 01.03.04 (2)
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.03.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.03.04
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.03.04 | Gebruiksfunctie | GO | Noord, West | 75.3187 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: J
01.03.04 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.03.05 (9)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.03.05
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group | GrossVolume (m3)
01.03.05 | 03 derde verdieping | Woonkamer-keuken | A 717 | 01 | 04 | Verblijfsruimte | 3 | 30.9787 | 85.1916 | 01; 01.03.05 | MiniBIM ILS - Orientatie: Noord, Oost
01.03.05 | 03 derde verdieping | Slaapkamer | A 718 | 01 | 02 | Verblijfsruimte | 3 | 13.6525 | 37.5444 | 01; 01.03.05 | 37.5444 | MiniBIM ILS - Orientatie: Noord
01.03.05 | 03 derde verdieping | Slaapkamer | A 719 | 01 | 03 | Verblijfsruimte | 3 | 7.9375 | 21.8281 | 01; 01.03.05 | 21.8281 | MiniBIM ILS - Orientatie: Noord
01.03.05 | 03 derde verdieping | Badruimte | A 720 | 01 | 05 | Restruimte | 3 | 5.5 | 15.125 | 01; 01.03.05
01.03.05 | 03 derde verdieping | Toiletruimte | A 721 | 01 | 07 | Restruimte | 3 | 1.1875 | 3.26562 | 01; 01.03.05 | 3.26562
01.03.05 | 03 derde verdieping | Bergruimte | A 722 | 01 | 06 | Restruimte | 3 | 4.1527 | 11.4199 | 01; 01.03.05 | 11.4199
01.03.05 | 03 derde verdieping | Schacht | A 723 | 01 | 08 | Restruimte | 3 | 0.255 | 0.765 | 01; 01.03.05 | 0.765
01.03.05 | 03 derde verdieping | Entree | A 724 | 01 | 01 | Restruimte | 3 | 11.2207 | 30.8569 | 01; 01.03.05 | 30.8569
01.03.05 | -1 kelder | Berging inpandig | A 1393 | 00 | 14 | Restruimte | 3.2 | 5.54625 | 17.748 | 01.03.05; 00 | 17.748

# IfcSpace: 01.03.05 (2)
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.03.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.03.05
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.03.05 | Gebruiksfunctie | GO | Noord, Oost | 77.3712 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: E
01.03.05 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.03.06 (10)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.03.06
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.03.06 | 03 derde verdieping | Slaapkamer | A 466 | 01 | 05 | Verblijfsruimte | 3 | 13.65 | 37.5375 | 01; 01.03.06 | MiniBIM ILS - Orientatie: Oost
01.03.06 | 03 derde verdieping | Slaapkamer | A 467 | 01 | 04 | Verblijfsruimte | 3 | 8.575 | 23.5813 | 01; 01.03.06 | MiniBIM ILS - Orientatie: Oost
01.03.06 | 03 derde verdieping | Woonkamer-keuken | A 468 | 01 | 02 | Verblijfsruimte | 3 | 31.9 | 87.725 | 01; 01.03.06 | MiniBIM ILS - Orientatie: Oost
