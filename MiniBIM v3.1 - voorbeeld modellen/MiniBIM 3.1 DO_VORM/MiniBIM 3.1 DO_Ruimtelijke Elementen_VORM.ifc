Properties of the parts of a building model (IFC4), part 2 of 12

# IfcSpace: 01.03.06 (10)
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.03.06 | 03 derde verdieping | Badruimte | A 469 | 01 | 06 | Restruimte | 3 | 4.16 | 11.44 | 01; 01.03.06 | Qto_SpaceBaseQuantities - GrossVolume: 11.44 m3
01.03.06 | 03 derde verdieping | Toiletruimte | A 470 | 01 | 08 | Restruimte | 3 | 1.1875 | 3.26562 | 01; 01.03.06 | Qto_SpaceBaseQuantities - GrossVolume: 3.26562 m3
01.03.06 | 03 derde verdieping | Schacht | A 471 | 01 | 09 | Restruimte | 3 | 0.42 | 1.26 | 01; 01.03.06 | Qto_SpaceBaseQuantities - GrossVolume: 1.26 m3
01.03.06 | 03 derde verdieping | Entree | A 472 | 01 | 01 | Restruimte | 3 | 4.62825 | 12.7277 | 01; 01.03.06 | Qto_SpaceBaseQuantities - GrossVolume: 12.7277 m3
01.03.06 | 03 derde verdieping | Gang | A 473 | 01 | 03 | Restruimte | 3 | 5.39 | 14.8225 | 01; 01.03.06 | Qto_SpaceBaseQuantities - GrossVolume: 14.8225 m3
01.03.06 | 03 derde verdieping | Bergruimte | A 474 | 01 | 07 | Restruimte | 3 | 4.83 | 13.2825 | 01; 01.03.06
01.03.06 | -1 kelder | Berging inpandig | A 1392 | 00 | 15 | Restruimte | 3.2 | 5.54625 | 16.3614 | 01.03.06; 00

# IfcSpace: 01.03.06 (2)
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.03.06; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.03.06
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.03.06 | Gebruiksfunctie | GO | 77.7495 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: F
01.03.06 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.04.01 (9)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.04.01
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.04.01 | 04 vierde verdieping | Woonkamer-keuken | A 207 | 01 | 04 | Verblijfsruimte | 3 | 26.6437 | 73.2703 | 01; 01.04.01 | MiniBIM ILS - Orientatie: Zuid, Oost
01.04.01 | 04 vierde verdieping | Slaapkamer | A 208 | 01 | 03 | Verblijfsruimte | 3 | 9.37125 | 25.7709 | 01; 01.04.01 | MiniBIM ILS - Orientatie: Zuid; Qto_SpaceBaseQuantities - GrossVolume: 25.7709 m3
01.04.01 | 04 vierde verdieping | Slaapkamer | A 209 | 01 | 03 | Verblijfsruimte | 3 | 13.975 | 38.4313 | 01; 01.04.01 | MiniBIM ILS - Orientatie: Oost
01.04.01 | 04 vierde verdieping | Entree | A 210 | 01 | 01 | Restruimte | 3 | 10.7332 | 29.5164 | 01; 01.04.01
01.04.01 | 04 vierde verdieping | Bergruimte | A 211 | 01 | 06 | Restruimte | 3 | 2.0925 | 5.75437 | 01; 01.04.01
01.04.01 | 04 vierde verdieping | Toiletruimte | A 212 | 01 | 07 | Restruimte | 3 | 1.1875 | 3.26563 | 01; 01.04.01 | Qto_SpaceBaseQuantities - GrossVolume: 3.26563 m3
01.04.01 | 04 vierde verdieping | Badruimte | A 213 | 01 | 05 | Restruimte | 3 | 4.16 | 11.44 | 01; 01.04.01 | Qto_SpaceBaseQuantities - GrossVolume: 11.44 m3
01.04.01 | 04 vierde verdieping | Schacht | A 214 | 01 | 08 | Restruimte | 3 | 0.375 | 1.125 | 01; 01.04.01 | Qto_SpaceBaseQuantities - GrossVolume: 1.125 m3
01.04.01 | -1 kelder | Berging inpandig | A 1388 | 00 | 16 | Restruimte | 3.2 | 5.54625 | 16.3614 | 01.04.01; 00

# IfcSpace: 01.04.01 (2)
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.04.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.04.01
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.04.01 | Gebruiksfunctie | GO | Zuid, Oost | 70.6182 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: G
01.04.01 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.04.02 (9)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.04.02
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.04.02 | 04 vierde verdieping | Woonkamer-keuken | A 95 | 01 | 04 | Verblijfsruimte | 3 | 30.9787 | 85.1916 | 01; 01.04.02 | MiniBIM ILS - Orientatie: Zuid, West
01.04.02 | 04 vierde verdieping | Slaapkamer | A 96 | 01 | 03 | Verblijfsruimte | 3 | 7.9375 | 21.8281 | 01; 01.04.02 | MiniBIM ILS - Orientatie: Zuid
01.04.02 | 04 vierde verdieping | Slaapkamer | A 97 | 01 | 02 | Verblijfsruimte | 3 | 14.1287 | 38.8541 | 01; 01.04.02 | MiniBIM ILS - Orientatie: Zuid
01.04.02 | 04 vierde verdieping | Badruimte | A 98 | 01 | 05 | Restruimte | 3 | 5.5 | 15.125 | 01; 01.04.02
01.04.02 | 04 vierde verdieping | Bergruimte | A 99 | 01 | 06 | Restruimte | 3 | 4.5025 | 12.3819 | 01; 01.04.02 | Qto_SpaceBaseQuantities - GrossVolume: 12.3819 m3
01.04.02 | 04 vierde verdieping | Toiletruimte | A 100 | 01 | 07 | Restruimte | 3 | 1.1875 | 3.26563 | 01; 01.04.02 | Qto_SpaceBaseQuantities - GrossVolume: 3.26563 m3
01.04.02 | 04 vierde verdieping | Schacht | A 101 | 01 | 08 | Restruimte | 3 | 0.255 | 0.765 | 01; 01.04.02 | Qto_SpaceBaseQuantities - GrossVolume: 0.765 m3
01.04.02 | 04 vierde verdieping | Entree | A 102 | 01 | 01 | Restruimte | 3 | 11.365 | 31.2538 | 01; 01.04.02 | Qto_SpaceBaseQuantities - GrossVolume: 31.2538 m3
01.04.02 | -1 kelder | Berging inpandig | A 1386 | 00 | 17 | Restruimte | 3.2 | 5.54625 | 16.3614 | 01.04.02; 00

# IfcSpace: 01.04.02 (2)
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.04.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.04.02
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.04.02 | Gebruiksfunctie | GO | Zuid, West | 78.3725 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: H
01.04.02 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.04.03 (12)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.04.03
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.04.03 | 04 vierde verdieping | Woonkamer-keuken | A 325 | 01 | 02 | Verblijfsruimte | 3 | 31.9 | 87.725 | 01; 01.04.03 | MiniBIM ILS - Orientatie: West
01.04.03 | 04 vierde verdieping | Badruimte | A 326 | 01 | 05 | Restruimte | 3 | 4.16 | 11.44 | 01; 01.04.03
01.04.03 | 04 vierde verdieping | Slaapkamer | A 327 | 01 | 03 | Verblijfsruimte | 3 | 11.1475 | 30.6556 | 01; 01.04.03 | MiniBIM ILS - Orientatie: West
01.04.03 | 04 vierde verdieping | Slaapkamer | A 328 | 01 | 04 | Verblijfsruimte | 3 | 13.65 | 37.5375 | 01; 01.04.03 | MiniBIM ILS - Orientatie: West
01.04.03 | 04 vierde verdieping | Bergruimte | A 329 | 01 | 09 | Restruimte | 3 | 1.78875 | 4.91906 | 01; 01.04.03
01.04.03 | 04 vierde verdieping | Toiletruimte | A 330 | 01 | 10 | Restruimte | 3 | 1.1875 | 3.26562 | 01; 01.04.03
01.04.03 | 04 vierde verdieping | Schacht | A 331 | 01 | 11 | Restruimte | 3 | 0.34375 | 1.03125 | 01; 01.04.03 | Qto_SpaceBaseQuantities - GrossVolume: 1.03125 m3
01.04.03 | 04 vierde verdieping | Entree | A 332 | 01 | 01 | Restruimte | 3 | 4.455 | 12.2513 | 01; 01.04.03
01.04.03 | 04 vierde verdieping | Bergruimte | A 333 | 01 | 07 | Restruimte | 3 | 2.1 | 5.775 | 01; 01.04.03
01.04.03 | 04 vierde verdieping | Bergruimte | A 334 | 01 | 06 | Restruimte | 3 | 3.15 | 8.6625 | 01; 01.04.03
01.04.03 | 04 vierde verdieping | Gang | A 335 | 01 | 08 | Restruimte | 3 | 4.235 | 11.6463 | 01; 01.04.03 | Qto_SpaceBaseQuantities - GrossVolume: 11.6463 m3
01.04.03 | -1 kelder | Berging inpandig | A 1382 | 00 | 18 | Restruimte | 3.2 | 5.54625 | 16.3614 | 01.04.03; 00

# IfcSpace: 01.04.03 (2)
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.04.03; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.04.03
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.04.03 | Gebruiksfunctie | GO | 81.4275 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: I
01.04.03 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.04.04 (10)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.04.04
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.04.04 | 04 vierde verdieping | Woonkamer-keuken | A 601 | 01 | 07 | Verblijfsruimte | 3 | 26.6437 | 73.2703 | 01; 01.04.04 | MiniBIM ILS - Orientatie: Noord, West
01.04.04 | 04 vierde verdieping | Slaapkamer | A 602 | 01 | 06 | Verblijfsruimte | 3 | 13.975 | 38.4313 | 01; 01.04.04 | MiniBIM ILS - Orientatie: West
01.04.04 | 04 vierde verdieping | Slaapkamer | A 603 | 01 | 08 | Verblijfsruimte | 3 | 9.9225 | 27.2869 | 01; 01.04.04 | MiniBIM ILS - Orientatie: Noord
01.04.04 | 04 vierde verdieping | Bergruimte | A 604 | 01 | 09 | Restruimte | 3 | 4.06 | 11.165 | 01; 01.04.04 | Qto_SpaceBaseQuantities - GrossVolume: 11.165 m3
01.04.04 | 04 vierde verdieping | Badruimte | A 605 | 01 | 05 | Restruimte | 3 | 4.16 | 11.44 | 01; 01.04.04
01.04.04 | 04 vierde verdieping | Toiletruimte | A 606 | 01 | 03 | Restruimte | 3 | 1.1875 | 3.26563 | 01; 01.04.04
01.04.04 | 04 vierde verdieping | Schacht | A 607 | 01 | 04 | Restruimte | 3 | 0.375 | 1.125 | 01; 01.04.04 | Qto_SpaceBaseQuantities - GrossVolume: 1.125 m3
01.04.04 | 04 vierde verdieping | Bergruimte | A 608 | 01 | 02 | Restruimte | 3 | 1.8225 | 5.01187 | 01; 01.04.04 | Qto_SpaceBaseQuantities - GrossVolume: 5.01187 m3
01.04.04 | 04 vierde verdieping | Entree | A 609 | 01 | 01 | Restruimte | 3 | 10.8075 | 29.7206 | 01; 01.04.04
01.04.04 | -1 kelder | Berging inpandig | A 1380 | 00 | 19 | Restruimte | 3.2 | 5.54625 | 16.3614 | 01.04.04; 00

# IfcSpace: 01.04.04 (2)
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.04.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.04.04
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.04.04 | Gebruiksfunctie | GO | Noord, West | 75.3187 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: J
01.04.04 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.04.05 (9)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.04.05
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group | GrossVolume (m3)
01.04.05 | 04 vierde verdieping | Woonkamer-keuken | A 725 | 01 | 04 | Verblijfsruimte | 3 | 30.9787 | 85.1916 | 01; 01.04.05 | MiniBIM ILS - Orientatie: Noord, Oost
01.04.05 | 04 vierde verdieping | Slaapkamer | A 726 | 01 | 02 | Verblijfsruimte | 3 | 13.6525 | 37.5444 | 01; 01.04.05 | 37.5444 | MiniBIM ILS - Orientatie: Noord
01.04.05 | 04 vierde verdieping | Slaapkamer | A 727 | 01 | 03 | Verblijfsruimte | 3 | 7.9375 | 21.8281 | 01; 01.04.05 | 21.8281 | MiniBIM ILS - Orientatie: Noord
01.04.05 | 04 vierde verdieping | Badruimte | A 728 | 01 | 05 | Restruimte | 3 | 5.5 | 15.125 | 01; 01.04.05
01.04.05 | 04 vierde verdieping | Toiletruimte | A 729 | 01 | 07 | Restruimte | 3 | 1.1875 | 3.26562 | 01; 01.04.05 | 3.26562
01.04.05 | 04 vierde verdieping | Bergruimte | A 730 | 01 | 06 | Restruimte | 3 | 4.1527 | 11.4199 | 01; 01.04.05 | 11.4199
01.04.05 | 04 vierde verdieping | Schacht | A 731 | 01 | 08 | Restruimte | 3 | 0.255 | 0.765 | 01; 01.04.05 | 0.765
01.04.05 | 04 vierde verdieping | Entree | A 732 | 01 | 01 | Restruimte | 3 | 11.2207 | 30.8569 | 01; 01.04.05 | 30.8569
01.04.05 | -1 kelder | Berging inpandig | A 1378 | 00 | 20 | Restruimte | 3.2 | 5.54625 | 16.3614 | 01.04.05; 00

# IfcSpace: 01.04.05 (2)
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.04.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.04.05
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.04.05 | Gebruiksfunctie | GO | Noord, Oost | 77.3712 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: E
01.04.05 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.04.06 (10)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 01.04.06
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | Group
01.04.06 | 04 vierde verdieping | Slaapkamer | A 475 | 01 | 05 | Verblijfsruimte | 3 | 13.65 | 37.5375 | 01; 01.04.06 | MiniBIM ILS - Orientatie: Oost
01.04.06 | 04 vierde verdieping | Slaapkamer | A 476 | 01 | 04 | Verblijfsruimte | 3 | 8.575 | 23.5813 | 01; 01.04.06 | MiniBIM ILS - Orientatie: Oost
01.04.06 | 04 vierde verdieping | Woonkamer-keuken | A 477 | 01 | 02 | Verblijfsruimte | 3 | 31.9 | 87.725 | 01; 01.04.06 | MiniBIM ILS - Orientatie: Oost
01.04.06 | 04 vierde verdieping | Badruimte | A 478 | 01 | 06 | Restruimte | 3 | 4.16 | 11.44 | 01; 01.04.06 | Qto_SpaceBaseQuantities - GrossVolume: 11.44 m3
01.04.06 | 04 vierde verdieping | Toiletruimte | A 479 | 01 | 08 | Restruimte | 3 | 1.1875 | 3.26562 | 01; 01.04.06 | Qto_SpaceBaseQuantities - GrossVolume: 3.26562 m3
01.04.06 | 04 vierde verdieping | Schacht | A 480 | 01 | 09 | Restruimte | 3 | 0.42 | 1.26 | 01; 01.04.06 | Qto_SpaceBaseQuantities - GrossVolume: 1.26 m3
01.04.06 | 04 vierde verdieping | Entree | A 481 | 01 | 01 | Restruimte | 3 | 4.62825 | 12.7277 | 01; 01.04.06 | Qto_SpaceBaseQuantities - GrossVolume: 12.7277 m3
01.04.06 | 04 vierde verdieping | Gang | A 482 | 01 | 03 | Restruimte | 3 | 5.39 | 14.8225 | 01; 01.04.06 | Qto_SpaceBaseQuantities - GrossVolume: 14.8225 m3
01.04.06 | 04 vierde verdieping | Bergruimte | A 483 | 01 | 07 | Restruimte | 3 | 4.83 | 13.2825 | 01; 01.04.06
01.04.06 | -1 kelder | Berging inpandig | A 1375 | 00 | 21 | Restruimte | 3.2 | 5.54625 | 16.3614 | 01.04.06; 00

# IfcSpace: 01.04.06 (2)
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.04.06; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.04.06
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.04.06 | Gebruiksfunctie | GO | 77.7495 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: F
01.04.06 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.05.01 (8)
In: 05 vijfde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.05.01
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.05.01 | Woonkamer-keuken | A 215 | 04 | Verblijfsruimte | 26.6437 | 73.2703 | MiniBIM ILS - Orientatie: Zuid, Oost
01.05.01 | Slaapkamer | A 216 | 03 | Verblijfsruimte | 9.37125 | 25.7709 | MiniBIM ILS - Orientatie: Zuid; Qto_SpaceBaseQuantities - GrossVolume: 25.7709 m3
01.05.01 | Slaapkamer | A 217 | 03 | Verblijfsruimte | 13.975 | 38.4313 | MiniBIM ILS - Orientatie: Oost
01.05.01 | Entree | A 218 | 01 | Restruimte | 10.7332 | 29.5164
01.05.01 | Bergruimte | A 219 | 06 | Restruimte | 2.0925 | 5.75437
01.05.01 | Toiletruimte | A 220 | 07 | Restruimte | 1.1875 | 3.26563 | Qto_SpaceBaseQuantities - GrossVolume: 3.26563 m3
01.05.01 | Badruimte | A 221 | 05 | Restruimte | 4.16 | 11.44 | Qto_SpaceBaseQuantities - GrossVolume: 11.44 m3
01.05.01 | Schacht | A 222 | 08 | Restruimte | 0.375 | 1.125 | Qto_SpaceBaseQuantities - GrossVolume: 1.125 m3

# IfcSpace: 01.05.01 (2)
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.05.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.05.01
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.05.01 | Gebruiksfunctie | GO | Zuid, Oost | 70.6182 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: G
01.05.01 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.05.02 (8)
In: 05 vijfde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.05.02
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.05.02 | Woonkamer-keuken | A 103 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Zuid, West
01.05.02 | Slaapkamer | A 104 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | MiniBIM ILS - Orientatie: Zuid
01.05.02 | Slaapkamer | A 105 | 02 | Verblijfsruimte | 14.1287 | 38.8541 | MiniBIM ILS - Orientatie: Zuid
01.05.02 | Badruimte | A 106 | 05 | Restruimte | 5.5 | 15.125
01.05.02 | Bergruimte | A 107 | 06 | Restruimte | 4.5025 | 12.3819 | Qto_SpaceBaseQuantities - GrossVolume: 12.3819 m3
01.05.02 | Toiletruimte | A 108 | 07 | Restruimte | 1.1875 | 3.26563 | Qto_SpaceBaseQuantities - GrossVolume: 3.26563 m3
01.05.02 | Schacht | A 109 | 08 | Restruimte | 0.255 | 0.765 | Qto_SpaceBaseQuantities - GrossVolume: 0.765 m3
01.05.02 | Entree | A 110 | 01 | Restruimte | 11.365 | 31.2538 | Qto_SpaceBaseQuantities - GrossVolume: 31.2538 m3

# IfcSpace: 01.05.02 (2)
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.05.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.05.02
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.05.02 | Gebruiksfunctie | GO | Zuid, West | 78.3725 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: H
01.05.02 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.05.03 (11)
In: 05 vijfde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.05.03
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.05.03 | Woonkamer-keuken | A 336 | 02 | Verblijfsruimte | 31.9 | 87.725 | MiniBIM ILS - Orientatie: West
01.05.03 | Badruimte | A 337 | 05 | Restruimte | 4.16 | 11.44
01.05.03 | Slaapkamer | A 338 | 03 | Verblijfsruimte | 11.1475 | 30.6556 | MiniBIM ILS - Orientatie: West
01.05.03 | Slaapkamer | A 339 | 04 | Verblijfsruimte | 13.65 | 37.5375 | MiniBIM ILS - Orientatie: West
01.05.03 | Bergruimte | A 340 | 09 | Restruimte | 1.78875 | 4.91906
01.05.03 | Toiletruimte | A 341 | 10 | Restruimte | 1.1875 | 3.26562
01.05.03 | Schacht | A 342 | 11 | Restruimte | 0.34375 | 1.03125 | Qto_SpaceBaseQuantities - GrossVolume: 1.03125 m3
01.05.03 | Entree | A 343 | 01 | Restruimte | 4.455 | 12.2513
01.05.03 | Bergruimte | A 344 | 07 | Restruimte | 2.1 | 5.775
01.05.03 | Bergruimte | A 345 | 06 | Restruimte | 3.15 | 8.6625
01.05.03 | Gang | A 346 | 08 | Restruimte | 4.235 | 11.6463 | Qto_SpaceBaseQuantities - GrossVolume: 11.6463 m3

# IfcSpace: 01.05.03 (2)
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.05.03; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.05.03
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.05.03 | Gebruiksfunctie | GO | 81.4275 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: I
01.05.03 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.05.04 (9)
In: 05 vijfde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.05.04
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.05.04 | Woonkamer-keuken | A 610 | 07 | Verblijfsruimte | 26.6437 | 73.2703 | MiniBIM ILS - Orientatie: Noord, West
01.05.04 | Slaapkamer | A 611 | 06 | Verblijfsruimte | 13.975 | 38.4313 | MiniBIM ILS - Orientatie: West
01.05.04 | Slaapkamer | A 612 | 08 | Verblijfsruimte | 9.9225 | 27.2869 | MiniBIM ILS - Orientatie: Noord
01.05.04 | Bergruimte | A 613 | 09 | Restruimte | 4.06 | 11.165 | Qto_SpaceBaseQuantities - GrossVolume: 11.165 m3
01.05.04 | Badruimte | A 614 | 05 | Restruimte | 4.16 | 11.44
01.05.04 | Toiletruimte | A 615 | 03 | Restruimte | 1.1875 | 3.26563
01.05.04 | Schacht | A 616 | 04 | Restruimte | 0.375 | 1.125 | Qto_SpaceBaseQuantities - GrossVolume: 1.125 m3
01.05.04 | Bergruimte | A 617 | 02 | Restruimte | 1.8225 | 5.01187 | Qto_SpaceBaseQuantities - GrossVolume: 5.01187 m3
01.05.04 | Entree | A 618 | 01 | Restruimte | 10.8075 | 29.7206

# IfcSpace: 01.05.04 (2)
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.05.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.05.04
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.05.04 | Gebruiksfunctie | GO | Noord, West | 75.3187 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: J
01.05.04 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.05.05 (8)
In: 05 vijfde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.05.05
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | GrossVolume (m3)
01.05.05 | Woonkamer-keuken | A 733 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Noord, Oost
01.05.05 | Slaapkamer | A 734 | 02 | Verblijfsruimte | 13.6525 | 37.5444 | 37.5444 | MiniBIM ILS - Orientatie: Noord
01.05.05 | Slaapkamer | A 735 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | 21.8281 | MiniBIM ILS - Orientatie: Noord
01.05.05 | Badruimte | A 736 | 05 | Restruimte | 5.5 | 15.125
01.05.05 | Toiletruimte | A 737 | 07 | Restruimte | 1.1875 | 3.26562 | 3.26562
01.05.05 | Bergruimte | A 738 | 06 | Restruimte | 4.1527 | 11.4199 | 11.4199
01.05.05 | Schacht | A 739 | 08 | Restruimte | 0.255 | 0.765 | 0.765
01.05.05 | Entree | A 740 | 01 | Restruimte | 11.2207 | 30.8569 | 30.8569

# IfcSpace: 01.05.05 (2)
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.05.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.05.05
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.05.05 | Gebruiksfunctie | GO | Noord, Oost | 77.3712 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: E
01.05.05 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.05.06 (9)
In: 05 vijfde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.05.06
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | GrossVolume (m3)
01.05.06 | Slaapkamer | A 484 | 05 | Verblijfsruimte | 13.65 | 37.5375 | MiniBIM ILS - Orientatie: Oost
01.05.06 | Slaapkamer | A 485 | 04 | Verblijfsruimte | 8.575 | 23.5813 | MiniBIM ILS - Orientatie: Oost
01.05.06 | Woonkamer-keuken | A 486 | 02 | Verblijfsruimte | 31.9 | 87.725 | MiniBIM ILS - Orientatie: Oost
01.05.06 | Badruimte | A 487 | 06 | Restruimte | 4.16 | 11.44 | 11.44
01.05.06 | Toiletruimte | A 488 | 08 | Restruimte | 1.1875 | 3.26562 | 3.26562
01.05.06 | Schacht | A 489 | 09 | Restruimte | 0.42 | 1.26 | 1.26
01.05.06 | Entree | A 490 | 01 | Restruimte | 4.62825 | 12.7277 | 12.7277
01.05.06 | Gang | A 491 | 03 | Restruimte | 5.39 | 14.8225 | 14.8225
01.05.06 | Bergruimte | A 492 | 07 | Restruimte | 4.83 | 13.2825

# IfcSpace: 01.05.06 (2)
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.05.06; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.05.06
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.05.06 | Gebruiksfunctie | GO | 77.7495 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: F
01.05.06 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.06.01 (8)
In: 06 zesde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.06.01
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.06.01 | Woonkamer-keuken | A 223 | 04 | Verblijfsruimte | 26.6437 | 73.2703 | MiniBIM ILS - Orientatie: Zuid, Oost
01.06.01 | Slaapkamer | A 224 | 03 | Verblijfsruimte | 9.37125 | 25.7709 | MiniBIM ILS - Orientatie: Zuid; Qto_SpaceBaseQuantities - GrossVolume: 25.7709 m3
01.06.01 | Slaapkamer | A 225 | 03 | Verblijfsruimte | 13.975 | 38.4313 | MiniBIM ILS - Orientatie: Oost
01.06.01 | Entree | A 226 | 01 | Restruimte | 10.7332 | 29.5164
01.06.01 | Bergruimte | A 227 | 06 | Restruimte | 2.0925 | 5.75437
01.06.01 | Toiletruimte | A 228 | 07 | Restruimte | 1.1875 | 3.26563 | Qto_SpaceBaseQuantities - GrossVolume: 3.26563 m3
01.06.01 | Badruimte | A 229 | 05 | Restruimte | 4.16 | 11.44 | Qto_SpaceBaseQuantities - GrossVolume: 11.44 m3
01.06.01 | Schacht | A 230 | 08 | Restruimte | 0.375 | 1.125 | Qto_SpaceBaseQuantities - GrossVolume: 1.125 m3

# IfcSpace: 01.06.01 (2)
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.06.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.06.01
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.06.01 | Gebruiksfunctie | GO | Zuid, Oost | 70.6182 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: G
01.06.01 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.06.02 (8)
In: 06 zesde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.06.02
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.06.02 | Woonkamer-keuken | A 111 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Zuid, West
01.06.02 | Slaapkamer | A 112 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | MiniBIM ILS - Orientatie: Zuid
01.06.02 | Slaapkamer | A 113 | 02 | Verblijfsruimte | 14.1287 | 38.8541 | MiniBIM ILS - Orientatie: Zuid
01.06.02 | Badruimte | A 114 | 05 | Restruimte | 5.5 | 15.125
01.06.02 | Bergruimte | A 115 | 06 | Restruimte | 4.5025 | 12.3819 | Qto_SpaceBaseQuantities - GrossVolume: 12.3819 m3
01.06.02 | Toiletruimte | A 116 | 07 | Restruimte | 1.1875 | 3.26563 | Qto_SpaceBaseQuantities - GrossVolume: 3.26563 m3
01.06.02 | Schacht | A 117 | 08 | Restruimte | 0.255 | 0.765 | Qto_SpaceBaseQuantities - GrossVolume: 0.765 m3
01.06.02 | Entree | A 118 | 01 | Restruimte | 11.365 | 31.2538 | Qto_SpaceBaseQuantities - GrossVolume: 31.2538 m3

# IfcSpace: 01.06.02 (2)
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.06.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.06.02
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.06.02 | Gebruiksfunctie | GO | Zuid, West | 78.3725 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: H
01.06.02 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.06.03 (11)
In: 06 zesde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.06.03
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.06.03 | Woonkamer-keuken | A 347 | 02 | Verblijfsruimte | 31.9 | 87.725 | MiniBIM ILS - Orientatie: West
01.06.03 | Badruimte | A 348 | 05 | Restruimte | 4.16 | 11.44
01.06.03 | Slaapkamer | A 349 | 03 | Verblijfsruimte | 11.1475 | 30.6556 | MiniBIM ILS - Orientatie: West
01.06.03 | Slaapkamer | A 350 | 04 | Verblijfsruimte | 13.65 | 37.5375 | MiniBIM ILS - Orientatie: West
01.06.03 | Bergruimte | A 351 | 09 | Restruimte | 1.78875 | 4.91906
01.06.03 | Toiletruimte | A 352 | 10 | Restruimte | 1.1875 | 3.26562
01.06.03 | Schacht | A 353 | 11 | Restruimte | 0.34375 | 1.03125 | Qto_SpaceBaseQuantities - GrossVolume: 1.03125 m3
01.06.03 | Entree | A 354 | 01 | Restruimte | 4.455 | 12.2513
01.06.03 | Bergruimte | A 355 | 07 | Restruimte | 2.1 | 5.775
01.06.03 | Bergruimte | A 356 | 06 | Restruimte | 3.15 | 8.6625
01.06.03 | Gang | A 357 | 08 | Restruimte | 4.235 | 11.6463 | Qto_SpaceBaseQuantities - GrossVolume: 11.6463 m3

# IfcSpace: 01.06.03 (2)
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.06.03; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.06.03
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.06.03 | Gebruiksfunctie | GO | 81.4275 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: I
01.06.03 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.06.04 (9)
In: 06 zesde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.06.04
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.06.04 | Woonkamer-keuken | A 619 | 07 | Verblijfsruimte | 26.6437 | 73.2703 | MiniBIM ILS - Orientatie: Noord, West
01.06.04 | Slaapkamer | A 620 | 06 | Verblijfsruimte | 13.975 | 38.4313 | MiniBIM ILS - Orientatie: West
01.06.04 | Slaapkamer | A 621 | 08 | Verblijfsruimte | 9.9225 | 27.2869 | MiniBIM ILS - Orientatie: Noord
01.06.04 | Bergruimte | A 622 | 09 | Restruimte | 4.06 | 11.165 | Qto_SpaceBaseQuantities - GrossVolume: 11.165 m3
01.06.04 | Badruimte | A 623 | 05 | Restruimte | 4.16 | 11.44
01.06.04 | Toiletruimte | A 624 | 03 | Restruimte | 1.1875 | 3.26563
01.06.04 | Schacht | A 625 | 04 | Restruimte | 0.375 | 1.125 | Qto_SpaceBaseQuantities - GrossVolume: 1.125 m3
01.06.04 | Bergruimte | A 626 | 02 | Restruimte | 1.8225 | 5.01187 | Qto_SpaceBaseQuantities - GrossVolume: 5.01187 m3
01.06.04 | Entree | A 627 | 01 | Restruimte | 10.8075 | 29.7206

# IfcSpace: 01.06.04 (2)
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.06.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.06.04
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.06.04 | Gebruiksfunctie | GO | Noord, West | 75.3187 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: J
01.06.04 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.06.05 (8)
In: 06 zesde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.06.05
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | GrossVolume (m3)
01.06.05 | Woonkamer-keuken | A 741 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Noord, Oost
01.06.05 | Slaapkamer | A 742 | 02 | Verblijfsruimte | 13.6525 | 37.5444 | 37.5444 | MiniBIM ILS - Orientatie: Noord
01.06.05 | Slaapkamer | A 743 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | 21.8281 | MiniBIM ILS - Orientatie: Noord
01.06.05 | Badruimte | A 744 | 05 | Restruimte | 5.5 | 15.125
01.06.05 | Toiletruimte | A 745 | 07 | Restruimte | 1.1875 | 3.26562 | 3.26562
01.06.05 | Bergruimte | A 746 | 06 | Restruimte | 4.1527 | 11.4199 | 11.4199
01.06.05 | Schacht | A 747 | 08 | Restruimte | 0.255 | 0.765 | 0.765
01.06.05 | Entree | A 748 | 01 | Restruimte | 11.2207 | 30.8569 | 30.8569

# IfcSpace: 01.06.05 (2)
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.06.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.06.05
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.06.05 | Gebruiksfunctie | GO | Noord, Oost | 77.3712 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: E
01.06.05 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.06.06 (9)
In: 06 zesde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.06.06
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | GrossVolume (m3)
01.06.06 | Slaapkamer | A 493 | 05 | Verblijfsruimte | 13.65 | 37.5375 | MiniBIM ILS - Orientatie: Oost
01.06.06 | Slaapkamer | A 494 | 04 | Verblijfsruimte | 8.575 | 23.5813 | MiniBIM ILS - Orientatie: Oost
01.06.06 | Woonkamer-keuken | A 495 | 02 | Verblijfsruimte | 31.9 | 87.725 | MiniBIM ILS - Orientatie: Oost
01.06.06 | Badruimte | A 496 | 06 | Restruimte | 4.16 | 11.44 | 11.44
01.06.06 | Toiletruimte | A 497 | 08 | Restruimte | 1.1875 | 3.26562 | 3.26562
01.06.06 | Schacht | A 498 | 09 | Restruimte | 0.42 | 1.26 | 1.26
01.06.06 | Entree | A 499 | 01 | Restruimte | 4.62825 | 12.7277 | 12.7277
01.06.06 | Gang | A 500 | 03 | Restruimte | 5.39 | 14.8225 | 14.8225
01.06.06 | Bergruimte | A 501 | 07 | Restruimte | 4.83 | 13.2825

# IfcSpace: 01.06.06 (2)
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.06.06; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.06.06
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.06.06 | Gebruiksfunctie | GO | 77.7495 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: F
01.06.06 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.07.01 (8)
In: 07 zevende verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.07.01
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.07.01 | Woonkamer-keuken | A 271 | 04 | Verblijfsruimte | 26.6437 | 73.2703 | MiniBIM ILS - Orientatie: Zuid, Oost
01.07.01 | Slaapkamer | A 272 | 03 | Verblijfsruimte | 9.37125 | 25.7709 | MiniBIM ILS - Orientatie: Zuid; Qto_SpaceBaseQuantities - GrossVolume: 25.7709 m3
01.07.01 | Slaapkamer | A 273 | 03 | Verblijfsruimte | 13.975 | 38.4313 | MiniBIM ILS - Orientatie: Oost
01.07.01 | Entree | A 274 | 01 | Restruimte | 10.7332 | 29.5164
01.07.01 | Bergruimte | A 275 | 06 | Restruimte | 2.0925 | 5.75437
01.07.01 | Toiletruimte | A 276 | 07 | Restruimte | 1.1875 | 3.26563 | Qto_SpaceBaseQuantities - GrossVolume: 3.26563 m3
01.07.01 | Badruimte | A 277 | 05 | Restruimte | 4.16 | 11.44 | Qto_SpaceBaseQuantities - GrossVolume: 11.44 m3
01.07.01 | Schacht | A 278 | 08 | Restruimte | 0.375 | 1.125 | Qto_SpaceBaseQuantities - GrossVolume: 1.125 m3

# IfcSpace: 01.07.01 (2)
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.07.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.07.01
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.07.01 | Gebruiksfunctie | GO | Zuid, Oost | 70.6182 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: G
01.07.01 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.07.02 (8)
In: 07 zevende verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.07.02
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.07.02 | Woonkamer-keuken | A 159 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Zuid, West
01.07.02 | Slaapkamer | A 160 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | MiniBIM ILS - Orientatie: Zuid
01.07.02 | Slaapkamer | A 161 | 02 | Verblijfsruimte | 14.1287 | 38.8541 | MiniBIM ILS - Orientatie: Zuid
01.07.02 | Badruimte | A 162 | 05 | Restruimte | 5.5 | 15.125
01.07.02 | Bergruimte | A 163 | 06 | Restruimte | 4.5025 | 12.3819 | Qto_SpaceBaseQuantities - GrossVolume: 12.3819 m3
01.07.02 | Toiletruimte | A 164 | 07 | Restruimte | 1.1875 | 3.26563 | Qto_SpaceBaseQuantities - GrossVolume: 3.26563 m3
01.07.02 | Schacht | A 165 | 08 | Restruimte | 0.255 | 0.765 | Qto_SpaceBaseQuantities - GrossVolume: 0.765 m3
01.07.02 | Entree | A 166 | 01 | Restruimte | 11.365 | 31.2538 | Qto_SpaceBaseQuantities - GrossVolume: 31.2538 m3

# IfcSpace: 01.07.02 (2)
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.07.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.07.02
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.07.02 | Gebruiksfunctie | GO | Zuid, West | 78.3725 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: H
01.07.02 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.07.03 (11)
In: 07 zevende verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.07.03
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.07.03 | Woonkamer-keuken | A 413 | 02 | Verblijfsruimte | 31.9 | 87.725 | MiniBIM ILS - Orientatie: West
01.07.03 | Badruimte | A 414 | 05 | Restruimte | 4.16 | 11.44
01.07.03 | Slaapkamer | A 415 | 03 | Verblijfsruimte | 11.1475 | 30.6556 | MiniBIM ILS - Orientatie: West
01.07.03 | Slaapkamer | A 416 | 04 | Verblijfsruimte | 13.65 | 37.5375 | MiniBIM ILS - Orientatie: West
01.07.03 | Bergruimte | A 417 | 09 | Restruimte | 1.78875 | 4.91906
01.07.03 | Toiletruimte | A 418 | 10 | Restruimte | 1.1875 | 3.26562
01.07.03 | Schacht | A 419 | 11 | Restruimte | 0.34375 | 1.03125 | Qto_SpaceBaseQuantities - GrossVolume: 1.03125 m3
01.07.03 | Entree | A 420 | 01 | Restruimte | 4.455 | 12.2513
01.07.03 | Bergruimte | A 421 | 07 | Restruimte | 2.1 | 5.775
01.07.03 | Bergruimte | A 422 | 06 | Restruimte | 3.15 | 8.6625
01.07.03 | Gang | A 423 | 08 | Restruimte | 4.235 | 11.6463 | Qto_SpaceBaseQuantities - GrossVolume: 11.6463 m3

# IfcSpace: 01.07.03 (2)
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.07.03; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.07.03
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.07.03 | Gebruiksfunctie | GO | 81.4275 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: I
01.07.03 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.07.04 (9)
In: 07 zevende verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.07.04
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.07.04 | Woonkamer-keuken | A 673 | 07 | Verblijfsruimte | 26.6437 | 73.2703 | MiniBIM ILS - Orientatie: Noord, West
01.07.04 | Slaapkamer | A 674 | 06 | Verblijfsruimte | 13.975 | 38.4313 | MiniBIM ILS - Orientatie: West
01.07.04 | Slaapkamer | A 675 | 08 | Verblijfsruimte | 9.9225 | 27.2869 | MiniBIM ILS - Orientatie: Noord
01.07.04 | Bergruimte | A 676 | 09 | Restruimte | 4.06 | 11.165 | Qto_SpaceBaseQuantities - GrossVolume: 11.165 m3
01.07.04 | Badruimte | A 677 | 05 | Restruimte | 4.16 | 11.44
01.07.04 | Toiletruimte | A 678 | 03 | Restruimte | 1.1875 | 3.26563
01.07.04 | Schacht | A 679 | 04 | Restruimte | 0.375 | 1.125 | Qto_SpaceBaseQuantities - GrossVolume: 1.125 m3
01.07.04 | Bergruimte | A 680 | 02 | Restruimte | 1.8225 | 5.01187 | Qto_SpaceBaseQuantities - GrossVolume: 5.01187 m3
01.07.04 | Entree | A 681 | 01 | Restruimte | 10.8075 | 29.7206

# IfcSpace: 01.07.04 (2)
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.07.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.07.04
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.07.04 | Gebruiksfunctie | GO | Noord, West | 75.3187 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: J
01.07.04 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.07.05 (8)
In: 07 zevende verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.07.05
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | GrossVolume (m3)
01.07.05 | Woonkamer-keuken | A 789 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Noord, Oost
01.07.05 | Slaapkamer | A 790 | 02 | Verblijfsruimte | 13.6525 | 37.5444 | 37.5444 | MiniBIM ILS - Orientatie: Noord
01.07.05 | Slaapkamer | A 791 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | 21.8281 | MiniBIM ILS - Orientatie: Noord
01.07.05 | Badruimte | A 792 | 05 | Restruimte | 5.5 | 15.125
01.07.05 | Toiletruimte | A 793 | 07 | Restruimte | 1.1875 | 3.26562 | 3.26562
01.07.05 | Bergruimte | A 794 | 06 | Restruimte | 4.1527 | 11.4199 | 11.4199
01.07.05 | Schacht | A 795 | 08 | Restruimte | 0.255 | 0.765 | 0.765
01.07.05 | Entree | A 796 | 01 | Restruimte | 11.2207 | 30.8569 | 30.8569

# IfcSpace: 01.07.05 (2)
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.07.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.07.05
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.07.05 | Gebruiksfunctie | GO | Noord, Oost | 77.3712 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: E
01.07.05 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.07.06 (9)
In: 07 zevende verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.07.06
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | GrossVolume (m3)
01.07.06 | Slaapkamer | A 547 | 05 | Verblijfsruimte | 13.65 | 37.5375 | MiniBIM ILS - Orientatie: Oost
01.07.06 | Slaapkamer | A 548 | 04 | Verblijfsruimte | 8.575 | 23.5813 | MiniBIM ILS - Orientatie: Oost
01.07.06 | Woonkamer-keuken | A 549 | 02 | Verblijfsruimte | 31.9 | 87.725 | MiniBIM ILS - Orientatie: Oost
01.07.06 | Badruimte | A 550 | 06 | Restruimte | 4.16 | 11.44 | 11.44
01.07.06 | Toiletruimte | A 551 | 08 | Restruimte | 1.1875 | 3.26562 | 3.26562
01.07.06 | Schacht | A 552 | 09 | Restruimte | 0.42 | 1.26 | 1.26
01.07.06 | Entree | A 553 | 01 | Restruimte | 4.62825 | 12.7277 | 12.7277
01.07.06 | Gang | A 554 | 03 | Restruimte | 5.39 | 14.8225 | 14.8225
01.07.06 | Bergruimte | A 555 | 07 | Restruimte | 4.83 | 13.2825

# IfcSpace: 01.07.06 (2)
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.07.06; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.07.06
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.07.06 | Gebruiksfunctie | GO | 77.7495 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: F
01.07.06 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.08.01 (8)
In: 08 achtste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.08.01
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.08.01 | Woonkamer-keuken | A 287 | 04 | Verblijfsruimte | 26.6437 | 73.2703 | MiniBIM ILS - Orientatie: Zuid, Oost
01.08.01 | Slaapkamer | A 288 | 03 | Verblijfsruimte | 9.37125 | 25.7709 | MiniBIM ILS - Orientatie: Zuid; Qto_SpaceBaseQuantities - GrossVolume: 25.7709 m3
01.08.01 | Slaapkamer | A 289 | 03 | Verblijfsruimte | 13.975 | 38.4313 | MiniBIM ILS - Orientatie: Oost
01.08.01 | Entree | A 290 | 01 | Restruimte | 10.7332 | 29.5164
01.08.01 | Bergruimte | A 291 | 06 | Restruimte | 2.0925 | 5.75437
01.08.01 | Toiletruimte | A 292 | 07 | Restruimte | 1.1875 | 3.26563 | Qto_SpaceBaseQuantities - GrossVolume: 3.26563 m3
01.08.01 | Badruimte | A 293 | 05 | Restruimte | 4.16 | 11.44 | Qto_SpaceBaseQuantities - GrossVolume: 11.44 m3
01.08.01 | Schacht | A 294 | 08 | Restruimte | 0.375 | 1.03125 | Qto_SpaceBaseQuantities - GrossVolume: 1.03125 m3

# IfcSpace: 01.08.01 (2)
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.08.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.08.01
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.08.01 | Gebruiksfunctie | GO | Zuid, Oost | 70.6182 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: G
01.08.01 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.08.02 (8)
In: 08 achtste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.08.02
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.08.02 | Woonkamer-keuken | A 175 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Zuid, West
01.08.02 | Slaapkamer | A 176 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | MiniBIM ILS - Orientatie: Zuid
01.08.02 | Slaapkamer | A 177 | 02 | Verblijfsruimte | 14.1287 | 38.8541 | MiniBIM ILS - Orientatie: Zuid
01.08.02 | Badruimte | A 178 | 05 | Restruimte | 5.5 | 15.125
01.08.02 | Bergruimte | A 179 | 06 | Restruimte | 4.5025 | 12.3819 | Qto_SpaceBaseQuantities - GrossVolume: 12.3819 m3
01.08.02 | Toiletruimte | A 180 | 07 | Restruimte | 1.1875 | 3.26563 | Qto_SpaceBaseQuantities - GrossVolume: 3.26563 m3
01.08.02 | Schacht | A 181 | 08 | Restruimte | 0.255 | 0.70125 | Qto_SpaceBaseQuantities - GrossVolume: 0.70125 m3
01.08.02 | Entree | A 182 | 01 | Restruimte | 11.365 | 31.2538 | Qto_SpaceBaseQuantities - GrossVolume: 31.2538 m3

# IfcSpace: 01.08.02 (2)
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.08.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.08.02
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.08.02 | Gebruiksfunctie | GO | Zuid, West | 78.3725 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: H
01.08.02 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.08.03 (11)
In: 08 achtste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.08.03
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.08.03 | Woonkamer-keuken | A 435 | 02 | Verblijfsruimte | 31.9 | 87.725 | MiniBIM ILS - Orientatie: West
01.08.03 | Badruimte | A 436 | 05 | Restruimte | 4.16 | 11.44
01.08.03 | Slaapkamer | A 437 | 03 | Verblijfsruimte | 11.1475 | 30.6556 | MiniBIM ILS - Orientatie: West
01.08.03 | Slaapkamer | A 438 | 04 | Verblijfsruimte | 13.65 | 37.5375 | MiniBIM ILS - Orientatie: West
01.08.03 | Bergruimte | A 439 | 09 | Restruimte | 1.78875 | 4.91906
01.08.03 | Toiletruimte | A 440 | 10 | Restruimte | 1.1875 | 3.26562
01.08.03 | Schacht | A 441 | 11 | Restruimte | 0.34375 | 0.945313 | Qto_SpaceBaseQuantities - GrossVolume: 0.945313 m3
01.08.03 | Entree | A 442 | 01 | Restruimte | 4.455 | 12.2513
01.08.03 | Bergruimte | A 443 | 07 | Restruimte | 2.1 | 5.775
01.08.03 | Bergruimte | A 444 | 06 | Restruimte | 3.15 | 8.6625
01.08.03 | Gang | A 445 | 08 | Restruimte | 4.235 | 11.6463 | Qto_SpaceBaseQuantities - GrossVolume: 11.6463 m3

# IfcSpace: 01.08.03 (2)
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.08.03; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.08.03
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.08.03 | Gebruiksfunctie | GO | 81.4275 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: I
01.08.03 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.08.04 (9)
In: 08 achtste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.08.04
