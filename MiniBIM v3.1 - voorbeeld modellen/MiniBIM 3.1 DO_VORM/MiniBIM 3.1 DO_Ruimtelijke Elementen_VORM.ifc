Properties of the parts of a building model (IFC4), part 3 of 12

# IfcSpace: 01.08.04 (9)
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.08.04 | Woonkamer-keuken | A 691 | 07 | Verblijfsruimte | 26.6437 | 73.2703 | MiniBIM ILS - Orientatie: Noord, West
01.08.04 | Slaapkamer | A 692 | 06 | Verblijfsruimte | 13.975 | 38.4313 | MiniBIM ILS - Orientatie: West
01.08.04 | Slaapkamer | A 693 | 08 | Verblijfsruimte | 9.9225 | 27.2869 | MiniBIM ILS - Orientatie: Noord
01.08.04 | Bergruimte | A 694 | 09 | Restruimte | 4.06 | 11.165 | Qto_SpaceBaseQuantities - GrossVolume: 11.165 m3
01.08.04 | Badruimte | A 695 | 05 | Restruimte | 4.16 | 11.44
01.08.04 | Toiletruimte | A 696 | 03 | Restruimte | 1.1875 | 3.26563
01.08.04 | Schacht | A 697 | 04 | Restruimte | 0.375 | 1.03125
01.08.04 | Bergruimte | A 698 | 02 | Restruimte | 1.8225 | 5.01187 | Qto_SpaceBaseQuantities - GrossVolume: 5.01187 m3
01.08.04 | Entree | A 699 | 01 | Restruimte | 10.8075 | 29.7206

# IfcSpace: 01.08.04 (2)
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.08.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.08.04
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.08.04 | Gebruiksfunctie | GO | Noord, West | 75.3187 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: J
01.08.04 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.08.05 (8)
In: 08 achtste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.08.05
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3) | GrossVolume (m3)
01.08.05 | Woonkamer-keuken | A 805 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Noord, Oost
01.08.05 | Slaapkamer | A 806 | 02 | Verblijfsruimte | 13.6525 | 37.5444 | 37.5444 | MiniBIM ILS - Orientatie: Noord
01.08.05 | Slaapkamer | A 807 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | 21.8281 | MiniBIM ILS - Orientatie: Noord
01.08.05 | Badruimte | A 808 | 05 | Restruimte | 5.5 | 15.125
01.08.05 | Toiletruimte | A 809 | 07 | Restruimte | 1.1875 | 3.26562 | 3.26562
01.08.05 | Bergruimte | A 810 | 06 | Restruimte | 4.1527 | 11.4199 | 11.4199
01.08.05 | Schacht | A 811 | 08 | Restruimte | 0.255 | 0.70125 | 0.70125
01.08.05 | Entree | A 812 | 01 | Restruimte | 11.2207 | 30.8569 | 30.8569

# IfcSpace: 01.08.05 (2)
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.08.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.08.05
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.08.05 | Gebruiksfunctie | GO | Noord, Oost | 77.3712 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: E
01.08.05 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Balkon

# IfcSpace: 01.08.06 (9)
In: 08 achtste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.08.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.08.06
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
01.08.06 | Slaapkamer | A 565 | 05 | Verblijfsruimte | 13.65 | 37.5375 | MiniBIM ILS - Orientatie: Oost
01.08.06 | Slaapkamer | A 566 | 04 | Verblijfsruimte | 8.575 | 23.5813 | MiniBIM ILS - Orientatie: Oost
01.08.06 | Woonkamer-keuken | A 567 | 02 | Verblijfsruimte | 31.9 | 87.725 | MiniBIM ILS - Orientatie: Oost
01.08.06 | Badruimte | A 568 | 06 | Restruimte | 4.16 | 11.44 | Qto_SpaceBaseQuantities - GrossVolume: 11.44 m3
01.08.06 | Toiletruimte | A 569 | 08 | Restruimte | 1.1875 | 3.26562 | Qto_SpaceBaseQuantities - GrossVolume: 3.26562 m3
01.08.06 | Schacht | A 570 | 09 | Restruimte | 0.42 | 1.155
01.08.06 | Entree | A 571 | 01 | Restruimte | 4.62825 | 12.7277 | Qto_SpaceBaseQuantities - GrossVolume: 12.7277 m3
01.08.06 | Gang | A 572 | 03 | Restruimte | 5.39 | 14.8225 | Qto_SpaceBaseQuantities - GrossVolume: 14.8225 m3
01.08.06 | Bergruimte | A 573 | 07 | Restruimte | 4.83 | 13.2825

# IfcSpace: 01.08.06 (2)
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 01; EenheidNummer: 01.08.06; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 01; 01.08.06
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
01.08.06 | Gebruiksfunctie | GO | 77.7495 | MiniBIM ILS - Afnemer: Particulier; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSK; WoningType: F
01.08.06 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.00.01 (13)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 02.00.01
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3) | Group
02.00.01 | 01 eerste verdieping | Slaapkamer | A 1219 | 02 | 10 | Verblijfsruimte | 3 | 9.67875 | 26.6166 | 26.6166 | 02; 02.00.01 | MiniBIM ILS - Orientatie: Noord
02.00.01 | 01 eerste verdieping | Slaapkamer | A 1220 | 02 | 11 | Verblijfsruimte | 3 | 6.37875 | 17.5416 | 17.5416 | 02; 02.00.01 | MiniBIM ILS - Orientatie: Noord
02.00.01 | 01 eerste verdieping | Slaapkamer | A 1221 | 02 | 12 | Verblijfsruimte | 3 | 14.7 | 40.425 | 40.425 | 02; 02.00.01 | MiniBIM ILS - Orientatie: Noord, West
02.00.01 | 01 eerste verdieping | Badruimte | A 1222 | 02 | 08 | Restruimte | 3 | 4.2575 | 11.7081 | 11.7081 | 02; 02.00.01
02.00.01 | 01 eerste verdieping | Schacht | A 1223 | 02 | 09 | Restruimte | 3 | 0.2 | 0.55 | 0.55 | 02; 02.00.01
02.00.01 | 01 eerste verdieping | Overloop | A 1224 | 02 | 07 | Restruimte | 3 | 5.915 |  | 16.2662 | 02; 02.00.01
02.00.01 | 00 begane grond | Woonkamer-keuken | A 1281 | 02 | 02 | Verblijfsruimte | 3.9 | 30.025 |  | 109.829 | 02; 02.00.01 | MiniBIM ILS - Orientatie: Noord, West
02.00.01 | 00 begane grond | Entree | A 1284 | 02 | 01 | Restruimte | 3.9 | 2.475 | 9.03375 | 9.03375 | 02; 02.00.01 | MiniBIM ILS - Orientatie: Noord
02.00.01 | 00 begane grond | Bergruimte | A 1287 | 02 | 03 | Restruimte | 3.9 | 5.7525 |  | 21.4806 | 02; 02.00.01
02.00.01 | 00 begane grond | Hal | A 1290 | 02 | 04 | Restruimte | 3.9 | 2.0925 |  | 7.63762 | 02; 02.00.01
02.00.01 | 00 begane grond | Toiletruimte | A 1293 | 02 | 05 | Restruimte | 3.9 | 1.14 | 4.161 | 4.161 | 02; 02.00.01
02.00.01 | 00 begane grond | Schacht | A 1296 | 02 | 06 | Restruimte | 3.9 | 0.2375 |  | 0.916875 | 02; 02.00.01
02.00.01 | -1 kelder | Berging inpandig | A 1371 | 00 | 37 | Restruimte | 3.2 | 5.54625 |  | 16.3614 | 02.00.01; 00

# IfcSpace: 02.00.01 (3)
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.00.01
Group: 02; 02.00.01
Name | In | LongName | Afnemer | Bepalingsmethode | GebiedsSoort | GebiedsType | Gebruiksbestemming | Orientatie | Programma | Segment | WoningType | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.00.01 | 00 begane grond | Gebruiksfunctie | Corporatie | GO | Gebruiksfunctie | Maisonette | Woonfunctie | Noord, West | 4 kamer | VSH | A | 3.9 | 43.1375
02.00.01 | 01 eerste verdieping | Gebruiksfunctie | Corporatie | GO | Gebruiksfunctie | Maisonette | Woonfunctie | Noord, West | 4 kamer | VSH | A | 3 | 43.1375
02.00.01 | 00 begane grond | {$this("GebiedsSoort")} |  | NVO |  |  |  | Noord |  |  |  | 3.9 | 15.085 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Tuin

# IfcSpace: 02.00.02 (13)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 02.00.02
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3) | Group
02.00.02 | 01 eerste verdieping | Slaapkamer | A 1213 | 02 | 10 | Verblijfsruimte | 3 | 9.67875 | 26.6166 | 26.6166 | 02; 02.00.02 | MiniBIM ILS - Orientatie: Noord
02.00.02 | 01 eerste verdieping | Slaapkamer | A 1214 | 02 | 11 | Verblijfsruimte | 3 | 6.37875 | 17.5416 | 17.5416 | 02; 02.00.02 | MiniBIM ILS - Orientatie: Noord
02.00.02 | 01 eerste verdieping | Slaapkamer | A 1215 | 02 | 12 | Verblijfsruimte | 3 | 14.7 | 40.425 | 40.425 | 02; 02.00.02 | MiniBIM ILS - Orientatie: Noord
02.00.02 | 01 eerste verdieping | Badruimte | A 1216 | 02 | 08 | Restruimte | 3 | 4.2575 | 11.7081 | 11.7081 | 02; 02.00.02
02.00.02 | 01 eerste verdieping | Schacht | A 1217 | 02 | 09 | Restruimte | 3 | 0.2 | 0.55 | 0.55 | 02; 02.00.02
02.00.02 | 01 eerste verdieping | Overloop | A 1218 | 02 | 07 | Restruimte | 3 | 5.915 | 16.2662 | 16.2662 | 02; 02.00.02
02.00.02 | 00 begane grond | Woonkamer-keuken | A 1280 | 02 | 02 | Verblijfsruimte | 3.9 | 30.025 |  | 109.829 | 02; 02.00.02 | MiniBIM ILS - Orientatie: Noord
02.00.02 | 00 begane grond | Entree | A 1283 | 02 | 01 | Restruimte | 3.9 | 2.475 | 9.03375 | 9.03375 | 02; 02.00.02 | MiniBIM ILS - Orientatie: Noord
02.00.02 | 00 begane grond | Bergruimte | A 1286 | 02 | 03 | Restruimte | 3.9 | 5.7525 |  | 21.4806 | 02; 02.00.02
02.00.02 | 00 begane grond | Hal | A 1289 | 02 | 04 | Restruimte | 3.9 | 2.0925 |  | 7.63762 | 02; 02.00.02
02.00.02 | 00 begane grond | Toiletruimte | A 1292 | 02 | 05 | Restruimte | 3.9 | 1.14 | 4.161 | 4.161 | 02; 02.00.02
02.00.02 | 00 begane grond | Schacht | A 1295 | 02 | 06 | Restruimte | 3.9 | 0.2375 |  | 0.916875 | 02; 02.00.02
02.00.02 | -1 kelder | Berging inpandig | A 1362 | 00 | 30 | Restruimte | 3.2 | 4.70375 | 13.8761 | 13.8761 | 02.00.02; 00

# IfcSpace: 02.00.02 (3)
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.00.02; Orientatie: Noord
Group: 02; 02.00.02
Name | In | LongName | Afnemer | Bepalingsmethode | GebiedsSoort | GebiedsType | Gebruiksbestemming | Programma | Segment | WoningType | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.00.02 | 00 begane grond | Gebruiksfunctie | Corporatie | GO | Gebruiksfunctie | Maisonette | Woonfunctie | 4 kamer | VSH | B | 3.9 | 43.1375
02.00.02 | 01 eerste verdieping | Gebruiksfunctie | Corporatie | GO | Gebruiksfunctie | Maisonette | Woonfunctie | 4 kamer | VSH | B | 3 | 43.1375
02.00.02 | 00 begane grond | {$this("GebiedsSoort")} |  | NVO |  |  |  |  |  |  | 3.9 | 14.49 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Tuin

# IfcSpace: 02.00.03 (13)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; EenheidNummer: 02.00.03
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | BouwwerkNummer | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3) | Group
02.00.03 | 01 eerste verdieping | Slaapkamer | A 1207 | 02 | 10 | Verblijfsruimte | 3 | 9.67875 | 26.6166 | 26.6166 | 02; 02.00.03 | MiniBIM ILS - Orientatie: Noord, Oost
02.00.03 | 01 eerste verdieping | Slaapkamer | A 1208 | 02 | 11 | Verblijfsruimte | 3 | 6.37875 | 17.5416 | 17.5416 | 02; 02.00.03 | MiniBIM ILS - Orientatie: Noord
02.00.03 | 01 eerste verdieping | Slaapkamer | A 1209 | 02 | 12 | Verblijfsruimte | 3 | 14.7 | 40.425 | 40.425 | 02; 02.00.03 | MiniBIM ILS - Orientatie: Noord
02.00.03 | 01 eerste verdieping | Badruimte | A 1210 | 02 | 08 | Restruimte | 3 | 4.2575 |  | 11.7081 | 02; 02.00.03
02.00.03 | 01 eerste verdieping | Schacht | A 1211 | 02 | 09 | Restruimte | 3 | 0.2 | 0.55 | 0.55 | 02; 02.00.03
02.00.03 | 01 eerste verdieping | Overloop | A 1212 | 02 | 07 | Restruimte | 3 | 5.915 | 16.2662 | 16.2662 | 02; 02.00.03
02.00.03 | 00 begane grond | Woonkamer-keuken | A 1279 | 02 | 02 | Verblijfsruimte | 3.9 | 30.025 |  | 109.829 | 02; 02.00.03 | MiniBIM ILS - Orientatie: Noord, Oost
02.00.03 | 00 begane grond | Entree | A 1282 | 02 | 01 | Restruimte | 3.9 | 2.475 | 9.03375 | 9.03375 | 02; 02.00.03 | MiniBIM ILS - Orientatie: Noord
02.00.03 | 00 begane grond | Bergruimte | A 1285 | 02 | 03 | Restruimte | 3.9 | 5.7525 |  | 21.4806 | 02; 02.00.03
02.00.03 | 00 begane grond | Hal | A 1288 | 02 | 04 | Restruimte | 3.9 | 2.0925 |  | 7.63762 | 02; 02.00.03
02.00.03 | 00 begane grond | Toiletruimte | A 1291 | 02 | 05 | Restruimte | 3.9 | 1.14 | 4.161 | 4.161 | 02; 02.00.03
02.00.03 | 00 begane grond | Schacht | A 1294 | 02 | 06 | Restruimte | 3.9 | 0.2375 |  | 0.916875 | 02; 02.00.03
02.00.03 | -1 kelder | Berging inpandig | A 1366 | 00 | 29 | Restruimte | 3.2 | 4.70375 |  | 13.8761 | 02.00.03; 00

# IfcSpace: 02.00.03 (3)
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.00.03
Group: 02; 02.00.03
Name | In | LongName | Afnemer | Bepalingsmethode | GebiedsSoort | GebiedsType | Gebruiksbestemming | Orientatie | Programma | Segment | WoningType | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.00.03 | 00 begane grond | Gebruiksfunctie | Corporatie | GO | Gebruiksfunctie | Maisonette | Woonfunctie | Noord, Oost | 4 kamer | VSH | A | 3.9 | 43.1375
02.00.03 | 01 eerste verdieping | Gebruiksfunctie | Corporatie | GO | Gebruiksfunctie | Maisonette | Woonfunctie | Noord, Oost | 4 kamer | VSH | A | 3 | 43.1375
02.00.03 | 00 begane grond | {$this("GebiedsSoort")} |  | NVO |  |  |  | Noord |  |  |  | 3.9 | 15.085 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Tuin

# IfcSpace: 02.00.04 (31)
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.00.04
Group: 02; 02.00.04
Name | In | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | Height (m) | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
02.00.04 | 01 eerste verdieping | Groepsruimte | A 1397 | 29 | Verblijfsruimte | 3 | 39.9813 | 109.948 | MiniBIM ILS - Orientatie: West
02.00.04 | 01 eerste verdieping | Bedruimte | A 1398 | 31 | Verblijfsruimte | 3 | 7.865 | 21.6288 | MiniBIM ILS - Orientatie: Zuid, West
02.00.04 | 01 eerste verdieping | Bedruimte | A 1399 | 30 | Verblijfsruimte | 3 | 7.865 | 21.6287 | MiniBIM ILS - Orientatie: Zuid
02.00.04 | 01 eerste verdieping | Groepsruimte | A 1400 | 23 | Verblijfsruimte | 3 | 39.9813 | 109.948 | MiniBIM ILS - Orientatie: Oost; Qto_SpaceBaseQuantities - GrossVolume: 109.948 m3
02.00.04 | 01 eerste verdieping | Bedruimte | A 1401 | 24 | Verblijfsruimte | 3 | 7.865 | 21.6288 | MiniBIM ILS - Orientatie: Zuid, Oost; Qto_SpaceBaseQuantities - GrossVolume: 21.6288 m3
02.00.04 | 01 eerste verdieping | Bedruimte | A 1402 | 25 | Verblijfsruimte | 3 | 7.865 | 21.6287 | MiniBIM ILS - Orientatie: Zuid; Qto_SpaceBaseQuantities - GrossVolume: 21.6287 m3
02.00.04 | 01 eerste verdieping | Badruimte | A 1403 | 26 | Restruimte | 3 | 8.018 | 22.0495
02.00.04 | 01 eerste verdieping | Schacht | A 1404 | 28 | Restruimte | 3 | 0.1375 | 0.378125
02.00.04 | 01 eerste verdieping | Schacht | A 1405 | 27 | Restruimte | 3 | 0.1375 | 0.378125
02.00.04 | 01 eerste verdieping | Schacht | A 1406 | 21 | Restruimte | 3 | 0.275 | 0.75625 | Qto_SpaceBaseQuantities - GrossVolume: 0.75625 m3
02.00.04 | 01 eerste verdieping | Toiletruimte | A 1407 | 20 | Restruimte | 3 | 1.331 | 3.66025
02.00.04 | 01 eerste verdieping | Gang | A 1408 | 19 | Restruimte | 3 | 8.7 | 23.925 | Qto_SpaceBaseQuantities - GrossVolume: 23.925 m3
02.00.04 | 01 eerste verdieping | Trappenhuis | A 1409 | 22 | Restruimte | 3 | 8.664 | 23.826
02.00.04 | 00 begane grond | Groepsruimte | A 1410 | 16 | Verblijfsruimte | 3.9 | 39.9813 | 145.932 | MiniBIM ILS - Orientatie: West; Qto_SpaceBaseQuantities - GrossVolume: 145.932 m3
02.00.04 | 00 begane grond | Bedruimte | A 1411 | 18 | Verblijfsruimte | 3.9 | 7.865 | 28.7073 | MiniBIM ILS - Orientatie: Zuid, West; Qto_SpaceBaseQuantities - GrossVolume: 28.7073 m3
02.00.04 | 00 begane grond | Bedruimte | A 1412 | 17 | Verblijfsruimte | 3.9 | 7.865 | 28.7072 | MiniBIM ILS - Orientatie: Zuid
02.00.04 | 00 begane grond | Groepsruimte | A 1413 | 10 | Verblijfsruimte | 3.9 | 39.9813 | 145.932 | MiniBIM ILS - Orientatie: Oost; Qto_SpaceBaseQuantities - GrossVolume: 145.932 m3
02.00.04 | 00 begane grond | Bedruimte | A 1414 | 11 | Verblijfsruimte | 3.9 | 7.865 | 28.7073 | MiniBIM ILS - Orientatie: Zuid, Oost; Qto_SpaceBaseQuantities - GrossVolume: 28.7073 m3
02.00.04 | 00 begane grond | Bedruimte | A 1415 | 12 | Verblijfsruimte | 3.9 | 7.865 | 28.7072 | MiniBIM ILS - Orientatie: Zuid
02.00.04 | 00 begane grond | Badruimte | A 1416 | 13 | Restruimte | 3.9 | 8.018 | 29.2657
02.00.04 | 00 begane grond | Schacht | A 1417 | 15 | Restruimte | 3.9 | 0.1375 | 0.501875
02.00.04 | 00 begane grond | Schacht | A 1418 | 14 | Restruimte | 3.9 | 0.1375 | 0.501875
02.00.04 | 00 begane grond | Schacht | A 1419 | 08 | Restruimte | 3.9 | 0.275 | 1.00375 | Qto_SpaceBaseQuantities - GrossVolume: 1.00375 m3
02.00.04 | 00 begane grond | Toiletruimte | A 1420 | 07 | Restruimte | 3.9 | 1.331 | 4.85815
02.00.04 | 00 begane grond | Gang | A 1421 | 02 | Restruimte | 3.9 | 56.6 | 206.59 | Qto_SpaceBaseQuantities - GrossVolume: 206.59 m3
02.00.04 | 00 begane grond | Bedrijfsruimte | A 1422 | 09 | Restruimte | 3.9 | 8.544 | 33.3216 | Qto_SpaceBaseQuantities - GrossVolume: 33.3216 m3
02.00.04 | 00 begane grond | Bedrijfsruimte | A 1423 | 03 | Restruimte | 3.9 | 10.56 | 38.6077
02.00.04 | 00 begane grond | Bedrijfsruimte | A 1424 | 05 | Restruimte | 3.9 | 5.76 | 21.024 | Qto_SpaceBaseQuantities - GrossVolume: 21.024 m3
02.00.04 | 00 begane grond | Wasruimte | A 1425 | 04 | Restruimte | 3.9 | 6.6 | 24.09 | Qto_SpaceBaseQuantities - GrossVolume: 24.09 m3
02.00.04 | 00 begane grond | Kantoorruimte | A 1426 | 01 | Verblijfsruimte | 3.9 | 16.0875 | 58.8 | MiniBIM ILS - Orientatie: Oost
02.00.04 | 00 begane grond | Berging inpandig | A 1427 | 07 | Restruimte | 3.9 | 10.35 | 37.8581

# IfcSpace: 02.00.04 (6)
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.00.04
Group: 02; 02.00.04
Name | In | LongName | Afnemer | Bepalingsmethode | GebiedsSoort | GebiedsType | Gebruiksbestemming | Height (m) | GrossFloorArea (m2) = GrossCeilingArea (m2) | NetFloorArea (m2)
02.00.04 | 00 begane grond | Gebruiksfunctie | Belegger | GO | Gebruiksfunctie | Kinderdagverblijf | Bijeenkomstfunctie | 3.9 | 248.875 | 247.525 | MiniBIM ILS - Segment: Huur
02.00.04 | 01 eerste verdieping | Gebruiksfunctie | Belegger | GO | Gebruiksfunctie | Kinderdagverblijf | Bijeenkomstfunctie | 3 | 143.2 | 143.2 | MiniBIM ILS - Segment: Huur
02.00.04 | 00 begane grond | {$this("GebiedsSoort")} |  | NVO |  |  |  | 3.9 | 32.69 | 32.69 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Tuin; Orientatie: Zuid
02.00.04 | 00 begane grond | {$this("GebiedsSoort")} |  | NVO |  |  |  | 3.9 | 167.977 | 167.977 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Dakterras; Orientatie: Zuid
02.00.04 | 01 eerste verdieping | Gebruiksfunctie | Belegger | VVO | Gebruiksfunctie | Kinderdagverblijf | Bijeenkomstfunctie | 3 | 143.2 | 143.2
02.00.04 | 00 begane grond | Gebruiksfunctie | Belegger | VVO | Gebruiksfunctie | Kinderdagverblijf | Bijeenkomstfunctie | 3.9 | 248.875 | 247.525

# IfcSpace: 02.01.01 (10)
In: 01 eerste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.01.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.01.01
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
02.01.01 | Woonkamer-keuken | A 1056 | 08 | Verblijfsruimte | 42.365 | 116.504 | MiniBIM ILS - Orientatie: West; Qto_SpaceBaseQuantities - GrossVolume: 116.504 m3
02.01.01 | Bergruimte | A 1057 | 09 | Restruimte | 4.675 | 12.8929
02.01.01 | Slaapkamer | A 1058 | 07 | Verblijfsruimte | 7.125 | 19.5938 | MiniBIM ILS - Orientatie: West; Qto_SpaceBaseQuantities - GrossVolume: 19.5938 m3
02.01.01 | Slaapkamer | A 1059 | 06 | Verblijfsruimte | 13.8775 | 38.1631 | MiniBIM ILS - Orientatie: West
02.01.01 | Toiletruimte | A 1060 | 02 | Restruimte | 1.33 | 3.6575 | Qto_SpaceBaseQuantities - GrossVolume: 3.6575 m3
02.01.01 | Schacht | A 1061 | 03 | Restruimte | 0.42 | 1.155 | Qto_SpaceBaseQuantities - GrossVolume: 1.155 m3
02.01.01 | Badruimte | A 1062 | 04 | Restruimte | 3.97 | 10.955
02.01.01 | Entree | A 1063 | 01 | Restruimte | 9.78575 | 26.9108
02.01.01 | Schacht | A 1064 | 05 | Restruimte | 0.32 | 0.94
02.01.01 | Schacht | A 1065 | 10 | Restruimte | 0.105 | 0.301087

# IfcSpace: 02.01.01 (2)
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.01.01; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.01.01
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.01.01 | Gebruiksfunctie | GO | 86.6632 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: C
02.01.01 | Area | NVO | 4.8 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Loggia

# IfcSpace: 02.01.02 (11)
In: 01 eerste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.01.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.01.02
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.01.02 | Woonkamer-keuken | A 1036 | 04 | Verblijfsruimte | 42.365 | 116.504 | 116.504 | MiniBIM ILS - Orientatie: Oost
02.01.02 | Slaapkamer | A 1037 | 05 | Verblijfsruimte | 7.125 | 19.5938 | 19.5938 | MiniBIM ILS - Orientatie: Oost
02.01.02 | Slaapkamer | A 1038 | 06 | Verblijfsruimte | 13.8775 |  | 38.1631 | MiniBIM ILS - Orientatie: Oost
02.01.02 | Badruimte | A 1039 | 07 | Restruimte | 4.16 | 11.44 | 11.44
02.01.02 | Bergruimte | A 1040 | 09 | Restruimte | 1.78875 |  | 5.01281
02.01.02 | Toiletruimte | A 1041 | 10 | Restruimte | 1.1875 | 3.26562 | 3.26562
02.01.02 | Schacht | A 1042 | 11 | Restruimte | 0.34375 |  | 0.945313
02.01.02 | Entree | A 1043 | 01 | Restruimte | 9.7225 | 26.7369 | 26.7369
02.01.02 | Schacht | A 1044 | 03 | Restruimte | 0.105 |  | 0.28875
02.01.02 | Bergruimte | A 1045 | 08 | Restruimte | 2.03 | 5.5825 | 5.5825
02.01.02 | Bergruimte | A 1046 | 02 | Restruimte | 4.675 | 12.8562 | 12.8562

# IfcSpace: 02.01.02 (2)
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.01.02; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.01.02
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.01.02 | Gebruiksfunctie | GO | 90.3375 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: D
02.01.02 | Area | NVO | 4.8 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Loggia

# IfcSpace: 02.01.03 (11)
In: 01 eerste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.01.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.01.03
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.01.03 | Woonkamer-keuken | A 1025 | 04 | Verblijfsruimte | 42.365 | 116.504 | 116.504 | MiniBIM ILS - Orientatie: Oost
02.01.03 | Slaapkamer | A 1026 | 05 | Verblijfsruimte | 7.125 | 19.5938 | 19.5938 | MiniBIM ILS - Orientatie: Oost
02.01.03 | Slaapkamer | A 1027 | 06 | Verblijfsruimte | 13.8775 |  | 38.1631 | MiniBIM ILS - Orientatie: Oost
02.01.03 | Badruimte | A 1028 | 07 | Restruimte | 4.16 | 11.44 | 11.44
02.01.03 | Bergruimte | A 1029 | 09 | Restruimte | 1.78875 | 4.91906 | 4.91906
02.01.03 | Toiletruimte | A 1030 | 10 | Restruimte | 1.1875 | 3.26562 | 3.26562
02.01.03 | Schacht | A 1031 | 11 | Restruimte | 0.34375 | 1.03125 | 1.03125
02.01.03 | Entree | A 1032 | 01 | Restruimte | 9.7225 | 26.7369 | 26.7369
02.01.03 | Schacht | A 1033 | 03 | Restruimte | 0.105 | 0.315 | 0.315
02.01.03 | Bergruimte | A 1034 | 08 | Restruimte | 2.03 | 5.5825 | 5.5825
02.01.03 | Bergruimte | A 1035 | 02 | Restruimte | 4.675 |  | 12.8863

# IfcSpace: 02.01.03 (2)
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.01.03; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.01.03
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.01.03 | Gebruiksfunctie | GO | 90.3375 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: D
02.01.03 | Area | NVO | 4.8 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Loggia

# IfcSpace: 02.01.04 (9)
In: 01 eerste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.01.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.01.04
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.01.04 | Woonkamer-keuken | A 1047 | 07 | Verblijfsruimte | 42.365 | 116.504 | 116.504 | MiniBIM ILS - Orientatie: West
02.01.04 | Bergruimte | A 1048 | 08 | Restruimte | 4.675 |  | 12.9163
02.01.04 | Schacht | A 1049 | 09 | Restruimte | 0.105 |  | 0.310625
02.01.04 | Slaapkamer | A 1050 | 06 | Verblijfsruimte | 7.125 | 19.5938 | 19.5938 | MiniBIM ILS - Orientatie: West
02.01.04 | Slaapkamer | A 1051 | 05 | Verblijfsruimte | 13.8775 |  | 38.1631 | MiniBIM ILS - Orientatie: West
02.01.04 | Toiletruimte | A 1052 | 02 | Restruimte | 1.33 | 3.6575 | 3.6575
02.01.04 | Schacht | A 1053 | 03 | Restruimte | 0.42 | 1.155 | 1.155
02.01.04 | Badruimte | A 1054 | 04 | Restruimte | 4.42 | 12.155 | 12.155
02.01.04 | Entree | A 1055 | 01 | Restruimte | 9.78575 | 26.9108 | 26.9108

# IfcSpace: 02.01.04 (2)
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.01.04; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.01.04
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.01.04 | Gebruiksfunctie | GO | 86.6632 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: C
02.01.04 | Area | NVO | 4.8 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Loggia

# IfcSpace: 02.02.01 (9)
In: 02 tweede verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.02.01
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.02.01 | Slaapkamer | A 502 | 05 | Verblijfsruimte | 13.65 | 37.5375 | 37.5375 | MiniBIM ILS - Orientatie: West
02.02.01 | Slaapkamer | A 503 | 04 | Verblijfsruimte | 8.575 | 23.5813 | 23.5813 | MiniBIM ILS - Orientatie: West
02.02.01 | Woonkamer-keuken | A 504 | 02 | Verblijfsruimte | 31.9 | 87.725 | 87.725 | MiniBIM ILS - Orientatie: West
02.02.01 | Badruimte | A 505 | 06 | Restruimte | 4.16 |  | 11.44
02.02.01 | Toiletruimte | A 506 | 08 | Restruimte | 1.1875 |  | 3.26562
02.02.01 | Schacht | A 507 | 09 | Restruimte | 0.42 | 1.26 | 1.26
02.02.01 | Entree | A 508 | 01 | Restruimte | 4.62825 |  | 12.7277
02.02.01 | Gang | A 509 | 03 | Restruimte | 5.39 |  | 14.8225
02.02.01 | Bergruimte | A 510 | 07 | Restruimte | 4.83 | 13.2825 | 13.2825

# IfcSpace: 02.02.01 (2)
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.02.01; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.02.01
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.02.01 | Gebruiksfunctie | GO | 77.7495 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: F
02.02.01 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.02.02 (8)
In: 02 tweede verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.02.02
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
02.02.02 | Woonkamer-keuken | A 749 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Noord, West; Qto_SpaceBaseQuantities - GrossVolume: 85.1916 m3
02.02.02 | Slaapkamer | A 750 | 02 | Verblijfsruimte | 13.6525 | 37.5444 | MiniBIM ILS - Orientatie: Noord
02.02.02 | Slaapkamer | A 751 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | MiniBIM ILS - Orientatie: Noord
02.02.02 | Badruimte | A 752 | 05 | Restruimte | 5.5 | 15.125 | Qto_SpaceBaseQuantities - GrossVolume: 15.125 m3
02.02.02 | Toiletruimte | A 753 | 07 | Restruimte | 1.1875 | 3.26562
02.02.02 | Bergruimte | A 754 | 06 | Restruimte | 4.1527 | 11.4199
02.02.02 | Schacht | A 755 | 08 | Restruimte | 0.255 | 0.765 | Qto_SpaceBaseQuantities - GrossVolume: 0.765 m3
02.02.02 | Entree | A 756 | 01 | Restruimte | 11.2207 | 30.8569

# IfcSpace: 02.02.02 (3)
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.02.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.02.02
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | BuitenruimteSoort | BuitenruimteType
02.02.02 | Gebruiksfunctie | GO | Noord, West | 77.3712 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: E
02.02.02 | Area | NVO | West | 6.27 | Overdekt | Balkon
02.02.02 | Area | NVO | Noord, West | 52.4839 | Niet-overdekt | Dakterras

# IfcSpace: 02.02.03 (9)
In: 02 tweede verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.02.03
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.02.03 | Woonkamer-keuken | A 628 | 07 | Verblijfsruimte | 26.6437 | 73.2703 | 73.2703 | MiniBIM ILS - Orientatie: Noord, Oost
02.02.03 | Slaapkamer | A 629 | 06 | Verblijfsruimte | 13.975 | 38.4313 | 38.4313 | MiniBIM ILS - Orientatie: Oost
02.02.03 | Slaapkamer | A 630 | 08 | Verblijfsruimte | 9.9225 | 27.2869 | 27.2869 | MiniBIM ILS - Orientatie: Noord
02.02.03 | Bergruimte | A 631 | 09 | Restruimte | 4.06 |  | 11.165
02.02.03 | Badruimte | A 632 | 05 | Restruimte | 4.16 | 11.44 | 11.44
02.02.03 | Toiletruimte | A 633 | 03 | Restruimte | 1.1875 | 3.26563 | 3.26563
02.02.03 | Schacht | A 634 | 04 | Restruimte | 0.375 | 1.125 | 1.125
02.02.03 | Bergruimte | A 635 | 02 | Restruimte | 1.8225 | 5.01187 | 5.01187
02.02.03 | Entree | A 636 | 01 | Restruimte | 10.8075 | 29.7206 | 29.7206

# IfcSpace: 02.02.03 (3)
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.02.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.02.03
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | BuitenruimteSoort | BuitenruimteType
02.02.03 | Gebruiksfunctie | GO | Noord, Oost | 75.3187 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: J
02.02.03 | Area | NVO | Oost | 6.27 | Overdekt | Balkon
02.02.03 | Area | NVO | Noord, Oost | 45.5639 | Niet-overdekt | Dakterras

# IfcSpace: 02.02.04 (11)
In: 02 tweede verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.02.04
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.02.04 | Woonkamer-keuken | A 358 | 02 | Verblijfsruimte | 31.9 | 87.725 | 87.725 | MiniBIM ILS - Orientatie: Oost
02.02.04 | Badruimte | A 359 | 05 | Restruimte | 4.16 | 11.44 | 11.44
02.02.04 | Slaapkamer | A 360 | 03 | Verblijfsruimte | 11.1475 | 30.6556 | 30.6556 | MiniBIM ILS - Orientatie: Oost
02.02.04 | Slaapkamer | A 361 | 04 | Verblijfsruimte | 13.65 | 37.5375 | 37.5375 | MiniBIM ILS - Orientatie: Oost
02.02.04 | Bergruimte | A 362 | 09 | Restruimte | 1.78875 | 4.91906 | 4.91906
02.02.04 | Toiletruimte | A 363 | 10 | Restruimte | 1.1875 | 3.26563 | 3.26563
02.02.04 | Schacht | A 364 | 11 | Restruimte | 0.34375 | 1.03125 | 1.03125
02.02.04 | Entree | A 365 | 01 | Restruimte | 4.455 | 12.2513 | 12.2513
02.02.04 | Bergruimte | A 366 | 07 | Restruimte | 2.1 | 5.775 | 5.775
02.02.04 | Bergruimte | A 367 | 06 | Restruimte | 3.15 | 8.6625 | 8.6625
02.02.04 | Gang | A 368 | 08 | Restruimte | 4.235 |  | 11.6463

# IfcSpace: 02.02.04 (2)
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.02.04; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.02.04
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.02.04 | Gebruiksfunctie | GO | 81.4275 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: I
02.02.04 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.02.05 (8)
In: 02 tweede verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.02.05
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.02.05 | Woonkamer-keuken | A 119 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | 85.1916 | MiniBIM ILS - Orientatie: Zuid, Oost
02.02.05 | Slaapkamer | A 120 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | 21.8281 | MiniBIM ILS - Orientatie: Zuid
02.02.05 | Slaapkamer | A 121 | 02 | Verblijfsruimte | 14.1287 | 38.8541 | 38.8541 | MiniBIM ILS - Orientatie: Zuid
02.02.05 | Badruimte | A 122 | 05 | Restruimte | 5.5 | 15.125 | 15.125
02.02.05 | Bergruimte | A 123 | 06 | Restruimte | 4.5025 | 12.3819 | 12.3819
02.02.05 | Toiletruimte | A 124 | 07 | Restruimte | 1.1875 |  | 3.26563
02.02.05 | Schacht | A 125 | 08 | Restruimte | 0.255 | 0.765 | 0.765
02.02.05 | Entree | A 126 | 01 | Restruimte | 11.365 |  | 31.2538

# IfcSpace: 02.02.05 (3)
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.02.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.02.05
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | BuitenruimteSoort | BuitenruimteType
02.02.05 | Gebruiksfunctie | GO | Zuid, Oost | 78.3725 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: H
02.02.05 | Area | NVO | Oost | 6.27 | Overdekt | Balkon
02.02.05 | Area | NVO | Zuid, Oost | 53.1326 | Niet-overdekt | Dakterras

# IfcSpace: 02.02.06 (8)
In: 02 tweede verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.02.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.02.06
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.02.06 | Woonkamer-keuken | A 231 | 04 | Verblijfsruimte | 26.6437 | 73.2703 | 73.2703 | MiniBIM ILS - Orientatie: Zuid, West
02.02.06 | Slaapkamer | A 232 | 03 | Verblijfsruimte | 9.37125 |  | 25.7709 | MiniBIM ILS - Orientatie: Zuid
02.02.06 | Slaapkamer | A 233 | 03 | Verblijfsruimte | 13.975 | 38.4313 | 38.4313 | MiniBIM ILS - Orientatie: West
02.02.06 | Entree | A 234 | 01 | Restruimte | 10.7332 | 29.5164 | 29.5164
02.02.06 | Bergruimte | A 235 | 06 | Restruimte | 2.0925 | 5.75437 | 5.75437
02.02.06 | Toiletruimte | A 236 | 07 | Restruimte | 1.1875 |  | 3.26563
02.02.06 | Badruimte | A 237 | 05 | Restruimte | 4.16 |  | 11.44
02.02.06 | Schacht | A 238 | 08 | Restruimte | 0.375 | 1.125 | 1.125

# IfcSpace: 02.02.06 (3)
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.02.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.02.06
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | BuitenruimteSoort | BuitenruimteType
02.02.06 | Gebruiksfunctie | GO | Zuid, West | 70.6182 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: G
02.02.06 | Area | NVO | West | 6.27 | Overdekt | Balkon
02.02.06 | Area | NVO | Zuid, West | 46.2126 | Niet-overdekt | Dakterras

# IfcSpace: 02.03.01 (9)
In: 03 derde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.03.01
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.03.01 | Slaapkamer | A 511 | 05 | Verblijfsruimte | 13.65 | 37.5375 | 37.5375 | MiniBIM ILS - Orientatie: West
02.03.01 | Slaapkamer | A 512 | 04 | Verblijfsruimte | 8.575 | 23.5813 | 23.5813 | MiniBIM ILS - Orientatie: West
02.03.01 | Woonkamer-keuken | A 513 | 02 | Verblijfsruimte | 31.9 | 87.725 | 87.725 | MiniBIM ILS - Orientatie: West
02.03.01 | Badruimte | A 514 | 06 | Restruimte | 4.16 |  | 11.44
02.03.01 | Toiletruimte | A 515 | 08 | Restruimte | 1.1875 |  | 3.26562
02.03.01 | Schacht | A 516 | 09 | Restruimte | 0.42 | 1.26 | 1.26
02.03.01 | Entree | A 517 | 01 | Restruimte | 4.62825 |  | 12.7277
02.03.01 | Gang | A 518 | 03 | Restruimte | 5.39 |  | 14.8225
02.03.01 | Bergruimte | A 519 | 07 | Restruimte | 4.83 | 13.2825 | 13.2825

# IfcSpace: 02.03.01 (2)
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.03.01; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.03.01
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.03.01 | Gebruiksfunctie | GO | 77.7495 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: F
02.03.01 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.03.02 (8)
In: 03 derde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.03.02
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
02.03.02 | Woonkamer-keuken | A 757 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Noord, West; Qto_SpaceBaseQuantities - GrossVolume: 85.1916 m3
02.03.02 | Slaapkamer | A 758 | 02 | Verblijfsruimte | 13.6525 | 37.5444 | MiniBIM ILS - Orientatie: Noord
02.03.02 | Slaapkamer | A 759 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | MiniBIM ILS - Orientatie: Noord
02.03.02 | Badruimte | A 760 | 05 | Restruimte | 5.5 | 15.125 | Qto_SpaceBaseQuantities - GrossVolume: 15.125 m3
02.03.02 | Toiletruimte | A 761 | 07 | Restruimte | 1.1875 | 3.26562
02.03.02 | Bergruimte | A 762 | 06 | Restruimte | 4.1527 | 11.4199
02.03.02 | Schacht | A 763 | 08 | Restruimte | 0.255 | 0.765 | Qto_SpaceBaseQuantities - GrossVolume: 0.765 m3
02.03.02 | Entree | A 764 | 01 | Restruimte | 11.2207 | 30.8569

# IfcSpace: 02.03.02 (2)
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.03.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.03.02
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.03.02 | Gebruiksfunctie | GO | Noord, West | 77.3712 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: E
02.03.02 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.03.03 (9)
In: 03 derde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.03.03
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.03.03 | Woonkamer-keuken | A 637 | 07 | Verblijfsruimte | 26.6437 | 73.2703 | 73.2703 | MiniBIM ILS - Orientatie: Noord, Oost
02.03.03 | Slaapkamer | A 638 | 06 | Verblijfsruimte | 13.975 | 38.4313 | 38.4313 | MiniBIM ILS - Orientatie: Oost
02.03.03 | Slaapkamer | A 639 | 08 | Verblijfsruimte | 9.9225 | 27.2869 | 27.2869 | MiniBIM ILS - Orientatie: Noord
02.03.03 | Bergruimte | A 640 | 09 | Restruimte | 4.06 |  | 11.165
02.03.03 | Badruimte | A 641 | 05 | Restruimte | 4.16 | 11.44 | 11.44
02.03.03 | Toiletruimte | A 642 | 03 | Restruimte | 1.1875 | 3.26563 | 3.26563
02.03.03 | Schacht | A 643 | 04 | Restruimte | 0.375 | 1.125 | 1.125
02.03.03 | Bergruimte | A 644 | 02 | Restruimte | 1.8225 | 5.01187 | 5.01187
02.03.03 | Entree | A 645 | 01 | Restruimte | 10.8075 | 29.7206 | 29.7206

# IfcSpace: 02.03.03 (2)
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.03.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.03.03
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.03.03 | Gebruiksfunctie | GO | Noord, Oost | 75.3187 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: J
02.03.03 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.03.04 (11)
In: 03 derde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.03.04
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.03.04 | Woonkamer-keuken | A 369 | 02 | Verblijfsruimte | 31.9 | 87.725 | 87.725 | MiniBIM ILS - Orientatie: Oost
02.03.04 | Badruimte | A 370 | 05 | Restruimte | 4.16 | 11.44 | 11.44
02.03.04 | Slaapkamer | A 371 | 03 | Verblijfsruimte | 11.1475 | 30.6556 | 30.6556 | MiniBIM ILS - Orientatie: Oost
02.03.04 | Slaapkamer | A 372 | 04 | Verblijfsruimte | 13.65 | 37.5375 | 37.5375 | MiniBIM ILS - Orientatie: Oost
02.03.04 | Bergruimte | A 373 | 09 | Restruimte | 1.78875 | 4.91906 | 4.91906
02.03.04 | Toiletruimte | A 374 | 10 | Restruimte | 1.1875 | 3.26563 | 3.26563
02.03.04 | Schacht | A 375 | 11 | Restruimte | 0.34375 | 1.03125 | 1.03125
02.03.04 | Entree | A 376 | 01 | Restruimte | 4.455 | 12.2513 | 12.2513
02.03.04 | Bergruimte | A 377 | 07 | Restruimte | 2.1 | 5.775 | 5.775
02.03.04 | Bergruimte | A 378 | 06 | Restruimte | 3.15 | 8.6625 | 8.6625
02.03.04 | Gang | A 379 | 08 | Restruimte | 4.235 |  | 11.6463

# IfcSpace: 02.03.04 (2)
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.03.04; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.03.04
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.03.04 | Gebruiksfunctie | GO | 81.4275 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: I
02.03.04 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.03.05 (8)
In: 03 derde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.03.05
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.03.05 | Woonkamer-keuken | A 127 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | 85.1916 | MiniBIM ILS - Orientatie: Zuid, Oost
02.03.05 | Slaapkamer | A 128 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | 21.8281 | MiniBIM ILS - Orientatie: Zuid
02.03.05 | Slaapkamer | A 129 | 02 | Verblijfsruimte | 14.1287 | 38.8541 | 38.8541 | MiniBIM ILS - Orientatie: Zuid
02.03.05 | Badruimte | A 130 | 05 | Restruimte | 5.5 | 15.125 | 15.125
02.03.05 | Bergruimte | A 131 | 06 | Restruimte | 4.5025 | 12.3819 | 12.3819
02.03.05 | Toiletruimte | A 132 | 07 | Restruimte | 1.1875 |  | 3.26563
02.03.05 | Schacht | A 133 | 08 | Restruimte | 0.255 | 0.765 | 0.765
02.03.05 | Entree | A 134 | 01 | Restruimte | 11.365 |  | 31.2538

# IfcSpace: 02.03.05 (2)
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.03.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.03.05
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.03.05 | Gebruiksfunctie | GO | Zuid, Oost | 78.3725 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: H
02.03.05 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.03.06 (8)
In: 03 derde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.03.06
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.03.06 | Woonkamer-keuken | A 239 | 04 | Verblijfsruimte | 26.6437 | 73.2703 | 73.2703 | MiniBIM ILS - Orientatie: Zuid, West
02.03.06 | Slaapkamer | A 240 | 03 | Verblijfsruimte | 9.37125 |  | 25.7709 | MiniBIM ILS - Orientatie: Zuid
02.03.06 | Slaapkamer | A 241 | 03 | Verblijfsruimte | 13.975 | 38.4313 | 38.4313 | MiniBIM ILS - Orientatie: West
02.03.06 | Entree | A 242 | 01 | Restruimte | 10.7332 | 29.5164 | 29.5164
02.03.06 | Bergruimte | A 243 | 06 | Restruimte | 2.0925 | 5.75437 | 5.75437
02.03.06 | Toiletruimte | A 244 | 07 | Restruimte | 1.1875 |  | 3.26563
02.03.06 | Badruimte | A 245 | 05 | Restruimte | 4.16 |  | 11.44
02.03.06 | Schacht | A 246 | 08 | Restruimte | 0.375 | 1.125 | 1.125

# IfcSpace: 02.03.06 (2)
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.03.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.03.06
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.03.06 | Gebruiksfunctie | GO | Zuid, West | 70.6182 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: G
02.03.06 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.04.01 (9)
In: 04 vierde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.04.01
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.04.01 | Slaapkamer | A 520 | 05 | Verblijfsruimte | 13.65 | 37.5375 | 37.5375 | MiniBIM ILS - Orientatie: West
02.04.01 | Slaapkamer | A 521 | 04 | Verblijfsruimte | 8.575 | 23.5813 | 23.5813 | MiniBIM ILS - Orientatie: West
02.04.01 | Woonkamer-keuken | A 522 | 02 | Verblijfsruimte | 31.9 | 87.725 | 87.725 | MiniBIM ILS - Orientatie: West
02.04.01 | Badruimte | A 523 | 06 | Restruimte | 4.16 |  | 11.44
02.04.01 | Toiletruimte | A 524 | 08 | Restruimte | 1.1875 |  | 3.26562
02.04.01 | Schacht | A 525 | 09 | Restruimte | 0.42 | 1.26 | 1.26
02.04.01 | Entree | A 526 | 01 | Restruimte | 4.62825 |  | 12.7277
02.04.01 | Gang | A 527 | 03 | Restruimte | 5.39 |  | 14.8225
02.04.01 | Bergruimte | A 528 | 07 | Restruimte | 4.83 | 13.2825 | 13.2825

# IfcSpace: 02.04.01 (2)
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.04.01; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.04.01
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.04.01 | Gebruiksfunctie | GO | 77.7495 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: F
02.04.01 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.04.02 (8)
In: 04 vierde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.04.02
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
02.04.02 | Woonkamer-keuken | A 765 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Noord, West; Qto_SpaceBaseQuantities - GrossVolume: 85.1916 m3
02.04.02 | Slaapkamer | A 766 | 02 | Verblijfsruimte | 13.6525 | 37.5444 | MiniBIM ILS - Orientatie: Noord
02.04.02 | Slaapkamer | A 767 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | MiniBIM ILS - Orientatie: Noord
02.04.02 | Badruimte | A 768 | 05 | Restruimte | 5.5 | 15.125 | Qto_SpaceBaseQuantities - GrossVolume: 15.125 m3
02.04.02 | Toiletruimte | A 769 | 07 | Restruimte | 1.1875 | 3.26562
02.04.02 | Bergruimte | A 770 | 06 | Restruimte | 4.1527 | 11.4199
02.04.02 | Schacht | A 771 | 08 | Restruimte | 0.255 | 0.765 | Qto_SpaceBaseQuantities - GrossVolume: 0.765 m3
02.04.02 | Entree | A 772 | 01 | Restruimte | 11.2207 | 30.8569

# IfcSpace: 02.04.02 (2)
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.04.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.04.02
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.04.02 | Gebruiksfunctie | GO | Noord, West | 77.3712 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: E
02.04.02 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.04.03 (9)
In: 04 vierde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.04.03
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.04.03 | Woonkamer-keuken | A 646 | 07 | Verblijfsruimte | 26.6437 | 73.2703 | 73.2703 | MiniBIM ILS - Orientatie: Noord, Oost
02.04.03 | Slaapkamer | A 647 | 06 | Verblijfsruimte | 13.975 | 38.4313 | 38.4313 | MiniBIM ILS - Orientatie: Oost
02.04.03 | Slaapkamer | A 648 | 08 | Verblijfsruimte | 9.9225 | 27.2869 | 27.2869 | MiniBIM ILS - Orientatie: Noord
02.04.03 | Bergruimte | A 649 | 09 | Restruimte | 4.06 |  | 11.165
02.04.03 | Badruimte | A 650 | 05 | Restruimte | 4.16 | 11.44 | 11.44
02.04.03 | Toiletruimte | A 651 | 03 | Restruimte | 1.1875 | 3.26563 | 3.26563
02.04.03 | Schacht | A 652 | 04 | Restruimte | 0.375 | 1.125 | 1.125
02.04.03 | Bergruimte | A 653 | 02 | Restruimte | 1.8225 | 5.01187 | 5.01187
02.04.03 | Entree | A 654 | 01 | Restruimte | 10.8075 | 29.7206 | 29.7206

# IfcSpace: 02.04.03 (2)
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.04.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.04.03
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.04.03 | Gebruiksfunctie | GO | Noord, Oost | 75.3187 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: J
02.04.03 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.04.04 (11)
In: 04 vierde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.04.04
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.04.04 | Woonkamer-keuken | A 380 | 02 | Verblijfsruimte | 31.9 | 87.725 | 87.725 | MiniBIM ILS - Orientatie: Oost
02.04.04 | Badruimte | A 381 | 05 | Restruimte | 4.16 | 11.44 | 11.44
02.04.04 | Slaapkamer | A 382 | 03 | Verblijfsruimte | 11.1475 | 30.6556 | 30.6556 | MiniBIM ILS - Orientatie: Oost
