Properties of the parts of a building model (IFC4), part 8 of 12

# IfcSpace: Area:1710132
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.03.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710134
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.03.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.48 m2; NetFloorArea: 6.48 m2; GrossCeilingArea: 6.48 m2

# IfcSpace: Area:1710136
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.03.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.42 m2; NetFloorArea: 25.42 m2; GrossCeilingArea: 25.42 m2

# IfcSpace: Area:1710138
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.03; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0288 m2; NetFloorArea: 20.0288 m2; GrossCeilingArea: 20.0288 m2

# IfcSpace: Area:1710140
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.03; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710142
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710144
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0387 m2; NetFloorArea: 25.0387 m2; GrossCeilingArea: 25.0387 m2

# IfcSpace: Area:1710146
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.9658 m2; NetFloorArea: 25.9658 m2; GrossCeilingArea: 25.9658 m2

# IfcSpace: Area:1710148
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.93416 m2; NetFloorArea: 5.93416 m2; GrossCeilingArea: 5.93416 m2

# IfcSpace: Area:1710150
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.06; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710152
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.06; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0287 m2; NetFloorArea: 20.0287 m2; GrossCeilingArea: 20.0287 m2

# IfcSpace: Area:1710154
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0388 m2; NetFloorArea: 25.0388 m2; GrossCeilingArea: 25.0388 m2

# IfcSpace: Area:1710156
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710158
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.48 m2; NetFloorArea: 6.48 m2; GrossCeilingArea: 6.48 m2

# IfcSpace: Area:1710160
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.03.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.42 m2; NetFloorArea: 25.42 m2; GrossCeilingArea: 25.42 m2

# IfcSpace: Area:1710165
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.04.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0288 m2; NetFloorArea: 20.0288 m2; GrossCeilingArea: 20.0288 m2

# IfcSpace: Area:1710167
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.04.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710169
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.04.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710171
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.04.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0387 m2; NetFloorArea: 25.0387 m2; GrossCeilingArea: 25.0387 m2

# IfcSpace: Area:1710173
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.04.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.9658 m2; NetFloorArea: 25.9658 m2; GrossCeilingArea: 25.9658 m2

# IfcSpace: Area:1710175
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.04.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.93416 m2; NetFloorArea: 5.93416 m2; GrossCeilingArea: 5.93416 m2

# IfcSpace: Area:1710177
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.04.01; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710179
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.04.01; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0287 m2; NetFloorArea: 20.0287 m2; GrossCeilingArea: 20.0287 m2

# IfcSpace: Area:1710181
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.04.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0388 m2; NetFloorArea: 25.0388 m2; GrossCeilingArea: 25.0388 m2

# IfcSpace: Area:1710183
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.04.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710185
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.04.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.48 m2; NetFloorArea: 6.48 m2; GrossCeilingArea: 6.48 m2

# IfcSpace: Area:1710187
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.04.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.42 m2; NetFloorArea: 25.42 m2; GrossCeilingArea: 25.42 m2

# IfcSpace: Area:1710189
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.03; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0288 m2; NetFloorArea: 20.0288 m2; GrossCeilingArea: 20.0288 m2

# IfcSpace: Area:1710191
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.03; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710193
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710195
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0387 m2; NetFloorArea: 25.0387 m2; GrossCeilingArea: 25.0387 m2

# IfcSpace: Area:1710197
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.9658 m2; NetFloorArea: 25.9658 m2; GrossCeilingArea: 25.9658 m2

# IfcSpace: Area:1710199
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.93416 m2; NetFloorArea: 5.93416 m2; GrossCeilingArea: 5.93416 m2

# IfcSpace: Area:1710201
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.06; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710203
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.06; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0287 m2; NetFloorArea: 20.0287 m2; GrossCeilingArea: 20.0287 m2

# IfcSpace: Area:1710205
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0388 m2; NetFloorArea: 25.0388 m2; GrossCeilingArea: 25.0388 m2

# IfcSpace: Area:1710207
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710209
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.48 m2; NetFloorArea: 6.48 m2; GrossCeilingArea: 6.48 m2

# IfcSpace: Area:1710211
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.42 m2; NetFloorArea: 25.42 m2; GrossCeilingArea: 25.42 m2

# IfcSpace: Area:1710216
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0288 m2; NetFloorArea: 20.0288 m2; GrossCeilingArea: 20.0288 m2

# IfcSpace: Area:1710218
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710220
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710222
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0387 m2; NetFloorArea: 25.0387 m2; GrossCeilingArea: 25.0387 m2

# IfcSpace: Area:1710224
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.9658 m2; NetFloorArea: 25.9658 m2; GrossCeilingArea: 25.9658 m2

# IfcSpace: Area:1710226
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.93416 m2; NetFloorArea: 5.93416 m2; GrossCeilingArea: 5.93416 m2

# IfcSpace: Area:1710228
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.01; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710230
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.01; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0287 m2; NetFloorArea: 20.0287 m2; GrossCeilingArea: 20.0287 m2

# IfcSpace: Area:1710232
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0388 m2; NetFloorArea: 25.0388 m2; GrossCeilingArea: 25.0388 m2

# IfcSpace: Area:1710234
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710236
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.48 m2; NetFloorArea: 6.48 m2; GrossCeilingArea: 6.48 m2

# IfcSpace: Area:1710238
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.05.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.42 m2; NetFloorArea: 25.42 m2; GrossCeilingArea: 25.42 m2

# IfcSpace: Area:1710240
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.03; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0288 m2; NetFloorArea: 20.0288 m2; GrossCeilingArea: 20.0288 m2

# IfcSpace: Area:1710242
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.03; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710244
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710246
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0387 m2; NetFloorArea: 25.0387 m2; GrossCeilingArea: 25.0387 m2

# IfcSpace: Area:1710248
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.9658 m2; NetFloorArea: 25.9658 m2; GrossCeilingArea: 25.9658 m2

# IfcSpace: Area:1710250
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.93416 m2; NetFloorArea: 5.93416 m2; GrossCeilingArea: 5.93416 m2

# IfcSpace: Area:1710252
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.06; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710254
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.06; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0287 m2; NetFloorArea: 20.0287 m2; GrossCeilingArea: 20.0287 m2

# IfcSpace: Area:1710256
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0388 m2; NetFloorArea: 25.0388 m2; GrossCeilingArea: 25.0388 m2

# IfcSpace: Area:1710258
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710260
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.48 m2; NetFloorArea: 6.48 m2; GrossCeilingArea: 6.48 m2

# IfcSpace: Area:1710262
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.42 m2; NetFloorArea: 25.42 m2; GrossCeilingArea: 25.42 m2

# IfcSpace: Area:1710267
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0288 m2; NetFloorArea: 20.0288 m2; GrossCeilingArea: 20.0288 m2

# IfcSpace: Area:1710269
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710271
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710273
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0387 m2; NetFloorArea: 25.0387 m2; GrossCeilingArea: 25.0387 m2

# IfcSpace: Area:1710275
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.9658 m2; NetFloorArea: 25.9658 m2; GrossCeilingArea: 25.9658 m2

# IfcSpace: Area:1710277
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.93416 m2; NetFloorArea: 5.93416 m2; GrossCeilingArea: 5.93416 m2

# IfcSpace: Area:1710279
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.01; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710281
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.01; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0287 m2; NetFloorArea: 20.0287 m2; GrossCeilingArea: 20.0287 m2

# IfcSpace: Area:1710283
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0388 m2; NetFloorArea: 25.0388 m2; GrossCeilingArea: 25.0388 m2

# IfcSpace: Area:1710285
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710287
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.48 m2; NetFloorArea: 6.48 m2; GrossCeilingArea: 6.48 m2

# IfcSpace: Area:1710289
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.06.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.42 m2; NetFloorArea: 25.42 m2; GrossCeilingArea: 25.42 m2

# IfcSpace: Area:1710291
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.03; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0288 m2; NetFloorArea: 20.0288 m2; GrossCeilingArea: 20.0288 m2

# IfcSpace: Area:1710293
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.03; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710295
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710297
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0387 m2; NetFloorArea: 25.0387 m2; GrossCeilingArea: 25.0387 m2

# IfcSpace: Area:1710299
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.9658 m2; NetFloorArea: 25.9658 m2; GrossCeilingArea: 25.9658 m2

# IfcSpace: Area:1710301
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.93416 m2; NetFloorArea: 5.93416 m2; GrossCeilingArea: 5.93416 m2

# IfcSpace: Area:1710303
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.06; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710305
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.06; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0287 m2; NetFloorArea: 20.0287 m2; GrossCeilingArea: 20.0287 m2

# IfcSpace: Area:1710307
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0388 m2; NetFloorArea: 25.0388 m2; GrossCeilingArea: 25.0388 m2

# IfcSpace: Area:1710309
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710311
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.48 m2; NetFloorArea: 6.48 m2; GrossCeilingArea: 6.48 m2

# IfcSpace: Area:1710313
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.42 m2; NetFloorArea: 25.42 m2; GrossCeilingArea: 25.42 m2

# IfcSpace: Area:1710318
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0288 m2; NetFloorArea: 20.0288 m2; GrossCeilingArea: 20.0288 m2

# IfcSpace: Area:1710320
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710322
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710324
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0387 m2; NetFloorArea: 25.0387 m2; GrossCeilingArea: 25.0387 m2

# IfcSpace: Area:1710326
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.9658 m2; NetFloorArea: 25.9658 m2; GrossCeilingArea: 25.9658 m2

# IfcSpace: Area:1710328
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.93416 m2; NetFloorArea: 5.93416 m2; GrossCeilingArea: 5.93416 m2

# IfcSpace: Area:1710330
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.01; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710332
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.01; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0287 m2; NetFloorArea: 20.0287 m2; GrossCeilingArea: 20.0287 m2

# IfcSpace: Area:1710334
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0388 m2; NetFloorArea: 25.0388 m2; GrossCeilingArea: 25.0388 m2

# IfcSpace: Area:1710336
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710338
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.48 m2; NetFloorArea: 6.48 m2; GrossCeilingArea: 6.48 m2

# IfcSpace: Area:1710340
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.07.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.42 m2; NetFloorArea: 25.42 m2; GrossCeilingArea: 25.42 m2

# IfcSpace: Area:1710342
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.03; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0288 m2; NetFloorArea: 20.0288 m2; GrossCeilingArea: 20.0288 m2

# IfcSpace: Area:1710344
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.03; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710346
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710348
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0387 m2; NetFloorArea: 25.0387 m2; GrossCeilingArea: 25.0387 m2

# IfcSpace: Area:1710350
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.9658 m2; NetFloorArea: 25.9658 m2; GrossCeilingArea: 25.9658 m2

# IfcSpace: Area:1710352
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.93416 m2; NetFloorArea: 5.93416 m2; GrossCeilingArea: 5.93416 m2

# IfcSpace: Area:1710354
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.06; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.615 m2; NetFloorArea: 6.615 m2; GrossCeilingArea: 6.615 m2

# IfcSpace: Area:1710356
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.06; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 20.0287 m2; NetFloorArea: 20.0287 m2; GrossCeilingArea: 20.0287 m2

# IfcSpace: Area:1710358
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.0388 m2; NetFloorArea: 25.0388 m2; GrossCeilingArea: 25.0388 m2

# IfcSpace: Area:1710360
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.05; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 5.94 m2; NetFloorArea: 5.94 m2; GrossCeilingArea: 5.94 m2

# IfcSpace: Area:1710362
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 6.48 m2; NetFloorArea: 6.48 m2; GrossCeilingArea: 6.48 m2

# IfcSpace: Area:1710364
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 25.42 m2; NetFloorArea: 25.42 m2; GrossCeilingArea: 25.42 m2

# IfcSpace: Area:1711246
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.01.03; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.865 m2; NetFloorArea: 31.865 m2; GrossCeilingArea: 31.865 m2

# IfcSpace: Area:1711248
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.01.03; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.5 m2; NetFloorArea: 10.5 m2; GrossCeilingArea: 10.5 m2

# IfcSpace: Area:1711271
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.01.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.865 m2; NetFloorArea: 31.865 m2; GrossCeilingArea: 31.865 m2

# IfcSpace: Area:1711273
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.01.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.5 m2; NetFloorArea: 10.5 m2; GrossCeilingArea: 10.5 m2

# IfcSpace: Area:1711277
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.01.01; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.865 m2; NetFloorArea: 31.865 m2; GrossCeilingArea: 31.865 m2

# IfcSpace: Area:1711279
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.01.01; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.5 m2; NetFloorArea: 10.5 m2; GrossCeilingArea: 10.5 m2

# IfcSpace: Area:1711283
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.01.04; RuimteNummer: 08; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.865 m2; NetFloorArea: 31.865 m2; GrossCeilingArea: 31.865 m2

# IfcSpace: Area:1711285
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.01.04; RuimteNummer: 08; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.5 m2; NetFloorArea: 10.5 m2; GrossCeilingArea: 10.5 m2

# IfcSpace: Area:1711289
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.01.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.865 m2; NetFloorArea: 31.865 m2; GrossCeilingArea: 31.865 m2

# IfcSpace: Area:1711291
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.01.02; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.5 m2; NetFloorArea: 10.5 m2; GrossCeilingArea: 10.5 m2

# IfcSpace: Area:1711293
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.01.03; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.865 m2; NetFloorArea: 31.865 m2; GrossCeilingArea: 31.865 m2

# IfcSpace: Area:1711295
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.01.03; RuimteNummer: 04; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.5 m2; NetFloorArea: 10.5 m2; GrossCeilingArea: 10.5 m2

# IfcSpace: Area:1711297
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.01.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.865 m2; NetFloorArea: 31.865 m2; GrossCeilingArea: 31.865 m2

# IfcSpace: Area:1711299
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.01.04; RuimteNummer: 07; RuimteSoort: Subruimte; RuimteType: Keuken
