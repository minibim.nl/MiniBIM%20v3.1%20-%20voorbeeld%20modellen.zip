Properties of the parts of a building model (IFC4), part 10 of 12

# IfcSpace: Area:1721910
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 57.617 m2; NetFloorArea: 57.617 m2; GrossCeilingArea: 57.617 m2

# IfcSpace: Area:1721912
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.43 m2; NetFloorArea: 14.43 m2; GrossCeilingArea: 14.43 m2

# IfcSpace: Area:1721914
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.79625 m2; NetFloorArea: 7.79625 m2; GrossCeilingArea: 7.79625 m2

# IfcSpace: Area:1721916
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721918
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.1288 m2; NetFloorArea: 14.1288 m2; GrossCeilingArea: 14.1288 m2

# IfcSpace: Area:1721920
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 23.43 m2; NetFloorArea: 23.43 m2; GrossCeilingArea: 23.43 m2

# IfcSpace: Area:1721922
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.37125 m2; NetFloorArea: 9.37125 m2; GrossCeilingArea: 9.37125 m2

# IfcSpace: Area:1721924
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1387 m2; NetFloorArea: 41.1387 m2; GrossCeilingArea: 41.1387 m2

# IfcSpace: Area:1721926
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 18.7533 m2; NetFloorArea: 18.7533 m2; GrossCeilingArea: 18.7533 m2

# IfcSpace: Area:1721928
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 54.7993 m2; NetFloorArea: 54.7993 m2; GrossCeilingArea: 54.7993 m2

# IfcSpace: Area:1721930
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 16.4025 m2; NetFloorArea: 16.4025 m2; GrossCeilingArea: 16.4025 m2

# IfcSpace: Area:1721932
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.62825 m2; NetFloorArea: 4.62825 m2; GrossCeilingArea: 4.62825 m2

# IfcSpace: Area:1721934
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721936
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 13.6525 m2; NetFloorArea: 13.6525 m2; GrossCeilingArea: 13.6525 m2

# IfcSpace: Area:1721938
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.92 m2; NetFloorArea: 22.92 m2; GrossCeilingArea: 22.92 m2

# IfcSpace: Area:1721940
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1721945
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1388 m2; NetFloorArea: 41.1388 m2; GrossCeilingArea: 41.1388 m2

# IfcSpace: Area:1721947
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.9225 m2; NetFloorArea: 9.9225 m2; GrossCeilingArea: 9.9225 m2

# IfcSpace: Area:1721949
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.8875 m2; NetFloorArea: 22.8875 m2; GrossCeilingArea: 22.8875 m2

# IfcSpace: Area:1721951
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 57.617 m2; NetFloorArea: 57.617 m2; GrossCeilingArea: 57.617 m2

# IfcSpace: Area:1721953
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.43 m2; NetFloorArea: 14.43 m2; GrossCeilingArea: 14.43 m2

# IfcSpace: Area:1721955
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.79625 m2; NetFloorArea: 7.79625 m2; GrossCeilingArea: 7.79625 m2

# IfcSpace: Area:1721957
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721959
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.1288 m2; NetFloorArea: 14.1288 m2; GrossCeilingArea: 14.1288 m2

# IfcSpace: Area:1721961
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 23.43 m2; NetFloorArea: 23.43 m2; GrossCeilingArea: 23.43 m2

# IfcSpace: Area:1721963
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.37125 m2; NetFloorArea: 9.37125 m2; GrossCeilingArea: 9.37125 m2

# IfcSpace: Area:1721965
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1387 m2; NetFloorArea: 41.1387 m2; GrossCeilingArea: 41.1387 m2

# IfcSpace: Area:1721967
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 18.7533 m2; NetFloorArea: 18.7533 m2; GrossCeilingArea: 18.7533 m2

# IfcSpace: Area:1721969
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 54.8345 m2; NetFloorArea: 54.8345 m2; GrossCeilingArea: 54.8345 m2

# IfcSpace: Area:1721971
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 16.4025 m2; NetFloorArea: 16.4025 m2; GrossCeilingArea: 16.4025 m2

# IfcSpace: Area:1721973
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.62825 m2; NetFloorArea: 4.62825 m2; GrossCeilingArea: 4.62825 m2

# IfcSpace: Area:1721975
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721977
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 13.6525 m2; NetFloorArea: 13.6525 m2; GrossCeilingArea: 13.6525 m2

# IfcSpace: Area:1721979
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.04.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.92 m2; NetFloorArea: 22.92 m2; GrossCeilingArea: 22.92 m2

# IfcSpace: Area:1721981
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1721983
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1388 m2; NetFloorArea: 41.1388 m2; GrossCeilingArea: 41.1388 m2

# IfcSpace: Area:1721985
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.9225 m2; NetFloorArea: 9.9225 m2; GrossCeilingArea: 9.9225 m2

# IfcSpace: Area:1721987
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.8875 m2; NetFloorArea: 22.8875 m2; GrossCeilingArea: 22.8875 m2

# IfcSpace: Area:1721989
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 57.617 m2; NetFloorArea: 57.617 m2; GrossCeilingArea: 57.617 m2

# IfcSpace: Area:1721991
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.43 m2; NetFloorArea: 14.43 m2; GrossCeilingArea: 14.43 m2

# IfcSpace: Area:1721993
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.79625 m2; NetFloorArea: 7.79625 m2; GrossCeilingArea: 7.79625 m2

# IfcSpace: Area:1721995
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721997
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.1288 m2; NetFloorArea: 14.1288 m2; GrossCeilingArea: 14.1288 m2

# IfcSpace: Area:1721999
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 23.43 m2; NetFloorArea: 23.43 m2; GrossCeilingArea: 23.43 m2

# IfcSpace: Area:1722001
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.37125 m2; NetFloorArea: 9.37125 m2; GrossCeilingArea: 9.37125 m2

# IfcSpace: Area:1722003
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1387 m2; NetFloorArea: 41.1387 m2; GrossCeilingArea: 41.1387 m2

# IfcSpace: Area:1722005
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 18.7533 m2; NetFloorArea: 18.7533 m2; GrossCeilingArea: 18.7533 m2

# IfcSpace: Area:1722007
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 54.7993 m2; NetFloorArea: 54.7993 m2; GrossCeilingArea: 54.7993 m2

# IfcSpace: Area:1722009
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 16.4025 m2; NetFloorArea: 16.4025 m2; GrossCeilingArea: 16.4025 m2

# IfcSpace: Area:1722011
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.62825 m2; NetFloorArea: 4.62825 m2; GrossCeilingArea: 4.62825 m2

# IfcSpace: Area:1722013
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1722015
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 13.6525 m2; NetFloorArea: 13.6525 m2; GrossCeilingArea: 13.6525 m2

# IfcSpace: Area:1722017
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.04.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.92 m2; NetFloorArea: 22.92 m2; GrossCeilingArea: 22.92 m2

# IfcSpace: Area:1722019
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1722024
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1388 m2; NetFloorArea: 41.1388 m2; GrossCeilingArea: 41.1388 m2

# IfcSpace: Area:1722026
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.9225 m2; NetFloorArea: 9.9225 m2; GrossCeilingArea: 9.9225 m2

# IfcSpace: Area:1722028
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.8875 m2; NetFloorArea: 22.8875 m2; GrossCeilingArea: 22.8875 m2

# IfcSpace: Area:1722030
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 57.617 m2; NetFloorArea: 57.617 m2; GrossCeilingArea: 57.617 m2

# IfcSpace: Area:1722032
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.43 m2; NetFloorArea: 14.43 m2; GrossCeilingArea: 14.43 m2

# IfcSpace: Area:1722034
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.79625 m2; NetFloorArea: 7.79625 m2; GrossCeilingArea: 7.79625 m2

# IfcSpace: Area:1722036
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1722038
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.1288 m2; NetFloorArea: 14.1288 m2; GrossCeilingArea: 14.1288 m2

# IfcSpace: Area:1722040
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 23.43 m2; NetFloorArea: 23.43 m2; GrossCeilingArea: 23.43 m2

# IfcSpace: Area:1722042
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.37125 m2; NetFloorArea: 9.37125 m2; GrossCeilingArea: 9.37125 m2

# IfcSpace: Area:1722044
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1387 m2; NetFloorArea: 41.1387 m2; GrossCeilingArea: 41.1387 m2

# IfcSpace: Area:1722046
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 18.7533 m2; NetFloorArea: 18.7533 m2; GrossCeilingArea: 18.7533 m2

# IfcSpace: Area:1722048
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 54.8345 m2; NetFloorArea: 54.8345 m2; GrossCeilingArea: 54.8345 m2

# IfcSpace: Area:1722050
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 16.4025 m2; NetFloorArea: 16.4025 m2; GrossCeilingArea: 16.4025 m2

# IfcSpace: Area:1722052
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.62825 m2; NetFloorArea: 4.62825 m2; GrossCeilingArea: 4.62825 m2

# IfcSpace: Area:1722054
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1722056
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 13.6525 m2; NetFloorArea: 13.6525 m2; GrossCeilingArea: 13.6525 m2

# IfcSpace: Area:1722058
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.05.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.92 m2; NetFloorArea: 22.92 m2; GrossCeilingArea: 22.92 m2

# IfcSpace: Area:1722060
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1722062
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1388 m2; NetFloorArea: 41.1388 m2; GrossCeilingArea: 41.1388 m2

# IfcSpace: Area:1722064
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.9225 m2; NetFloorArea: 9.9225 m2; GrossCeilingArea: 9.9225 m2

# IfcSpace: Area:1722066
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.8875 m2; NetFloorArea: 22.8875 m2; GrossCeilingArea: 22.8875 m2

# IfcSpace: Area:1722068
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 57.617 m2; NetFloorArea: 57.617 m2; GrossCeilingArea: 57.617 m2

# IfcSpace: Area:1722070
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.43 m2; NetFloorArea: 14.43 m2; GrossCeilingArea: 14.43 m2

# IfcSpace: Area:1722072
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.79625 m2; NetFloorArea: 7.79625 m2; GrossCeilingArea: 7.79625 m2

# IfcSpace: Area:1722074
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1722076
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.1288 m2; NetFloorArea: 14.1288 m2; GrossCeilingArea: 14.1288 m2

# IfcSpace: Area:1722078
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 23.43 m2; NetFloorArea: 23.43 m2; GrossCeilingArea: 23.43 m2

# IfcSpace: Area:1722080
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.37125 m2; NetFloorArea: 9.37125 m2; GrossCeilingArea: 9.37125 m2

# IfcSpace: Area:1722082
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1387 m2; NetFloorArea: 41.1387 m2; GrossCeilingArea: 41.1387 m2

# IfcSpace: Area:1722084
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 18.7533 m2; NetFloorArea: 18.7533 m2; GrossCeilingArea: 18.7533 m2

# IfcSpace: Area:1722086
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 54.7993 m2; NetFloorArea: 54.7993 m2; GrossCeilingArea: 54.7993 m2

# IfcSpace: Area:1722088
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 16.4025 m2; NetFloorArea: 16.4025 m2; GrossCeilingArea: 16.4025 m2

# IfcSpace: Area:1722090
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.62825 m2; NetFloorArea: 4.62825 m2; GrossCeilingArea: 4.62825 m2

# IfcSpace: Area:1722092
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1722094
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 13.6525 m2; NetFloorArea: 13.6525 m2; GrossCeilingArea: 13.6525 m2

# IfcSpace: Area:1722096
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.05.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.92 m2; NetFloorArea: 22.92 m2; GrossCeilingArea: 22.92 m2

# IfcSpace: Area:1722098
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1722103
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1388 m2; NetFloorArea: 41.1388 m2; GrossCeilingArea: 41.1388 m2

# IfcSpace: Area:1722105
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.9225 m2; NetFloorArea: 9.9225 m2; GrossCeilingArea: 9.9225 m2

# IfcSpace: Area:1722107
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.8875 m2; NetFloorArea: 22.8875 m2; GrossCeilingArea: 22.8875 m2

# IfcSpace: Area:1722109
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 57.617 m2; NetFloorArea: 57.617 m2; GrossCeilingArea: 57.617 m2

# IfcSpace: Area:1722111
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.43 m2; NetFloorArea: 14.43 m2; GrossCeilingArea: 14.43 m2

# IfcSpace: Area:1722113
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.79625 m2; NetFloorArea: 7.79625 m2; GrossCeilingArea: 7.79625 m2

# IfcSpace: Area:1722115
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1722117
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.1288 m2; NetFloorArea: 14.1288 m2; GrossCeilingArea: 14.1288 m2

# IfcSpace: Area:1722119
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 23.43 m2; NetFloorArea: 23.43 m2; GrossCeilingArea: 23.43 m2

# IfcSpace: Area:1722121
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.37125 m2; NetFloorArea: 9.37125 m2; GrossCeilingArea: 9.37125 m2

# IfcSpace: Area:1722123
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1387 m2; NetFloorArea: 41.1387 m2; GrossCeilingArea: 41.1387 m2

# IfcSpace: Area:1722125
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 18.7533 m2; NetFloorArea: 18.7533 m2; GrossCeilingArea: 18.7533 m2

# IfcSpace: Area:1722127
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 54.8345 m2; NetFloorArea: 54.8345 m2; GrossCeilingArea: 54.8345 m2

# IfcSpace: Area:1722129
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 16.4025 m2; NetFloorArea: 16.4025 m2; GrossCeilingArea: 16.4025 m2

# IfcSpace: Area:1722131
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.62825 m2; NetFloorArea: 4.62825 m2; GrossCeilingArea: 4.62825 m2

# IfcSpace: Area:1722133
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1722135
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 13.6525 m2; NetFloorArea: 13.6525 m2; GrossCeilingArea: 13.6525 m2

# IfcSpace: Area:1722137
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.06.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.92 m2; NetFloorArea: 22.92 m2; GrossCeilingArea: 22.92 m2

# IfcSpace: Area:1722139
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1722141
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1388 m2; NetFloorArea: 41.1388 m2; GrossCeilingArea: 41.1388 m2

# IfcSpace: Area:1722143
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.9225 m2; NetFloorArea: 9.9225 m2; GrossCeilingArea: 9.9225 m2

# IfcSpace: Area:1722145
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.8875 m2; NetFloorArea: 22.8875 m2; GrossCeilingArea: 22.8875 m2

# IfcSpace: Area:1722147
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 57.617 m2; NetFloorArea: 57.617 m2; GrossCeilingArea: 57.617 m2

# IfcSpace: Area:1722149
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.43 m2; NetFloorArea: 14.43 m2; GrossCeilingArea: 14.43 m2

# IfcSpace: Area:1722151
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.79625 m2; NetFloorArea: 7.79625 m2; GrossCeilingArea: 7.79625 m2

# IfcSpace: Area:1722153
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1722155
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
