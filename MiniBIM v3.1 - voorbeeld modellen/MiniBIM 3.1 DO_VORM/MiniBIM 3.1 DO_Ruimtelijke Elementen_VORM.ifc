Properties of the parts of a building model (IFC4), part 9 of 12

# IfcSpace: Area:1711299
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.5 m2; NetFloorArea: 10.5 m2; GrossCeilingArea: 10.5 m2

# IfcSpace: Area:1711301
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.01.01; RuimteNummer: 08; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.865 m2; NetFloorArea: 31.865 m2; GrossCeilingArea: 31.865 m2

# IfcSpace: Area:1711303
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.01.01; RuimteNummer: 08; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.5 m2; NetFloorArea: 10.5 m2; GrossCeilingArea: 10.5 m2

# IfcSpace: Area:1711815
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.00.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 7.74 m2; NetFloorArea: 7.74 m2; GrossCeilingArea: 7.74 m2

# IfcSpace: Area:1711818
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.00.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 22.285 m2; NetFloorArea: 22.285 m2; GrossCeilingArea: 22.285 m2

# IfcSpace: Area:1711872
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.00.02; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 7.74 m2; NetFloorArea: 7.74 m2; GrossCeilingArea: 7.74 m2

# IfcSpace: Area:1711874
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.00.02; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 22.285 m2; NetFloorArea: 22.285 m2; GrossCeilingArea: 22.285 m2

# IfcSpace: Area:1711894
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.00.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 7.74 m2; NetFloorArea: 7.74 m2; GrossCeilingArea: 7.74 m2

# IfcSpace: Area:1711896
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.00.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 22.285 m2; NetFloorArea: 22.285 m2; GrossCeilingArea: 22.285 m2

# IfcSpace: Area:1711916
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.00.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 7.74 m2; NetFloorArea: 7.74 m2; GrossCeilingArea: 7.74 m2

# IfcSpace: Area:1711918
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.00.03; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 22.285 m2; NetFloorArea: 22.285 m2; GrossCeilingArea: 22.285 m2

# IfcSpace: Area:1711929
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.00.02; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 7.74 m2; NetFloorArea: 7.74 m2; GrossCeilingArea: 7.74 m2

# IfcSpace: Area:1711931
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.00.02; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 22.285 m2; NetFloorArea: 22.285 m2; GrossCeilingArea: 22.285 m2

# IfcSpace: Area:1711942
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.00.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 7.74 m2; NetFloorArea: 7.74 m2; GrossCeilingArea: 7.74 m2

# IfcSpace: Area:1711944
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.00.01; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 22.285 m2; NetFloorArea: 22.285 m2; GrossCeilingArea: 22.285 m2

# IfcSpace: Area:1711977
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.00.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 7.74 m2; NetFloorArea: 7.74 m2; GrossCeilingArea: 7.74 m2

# IfcSpace: Area:1711979
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.00.06; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 22.285 m2; NetFloorArea: 22.285 m2; GrossCeilingArea: 22.285 m2

# IfcSpace: Area:1711990
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.00.05; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 7.74 m2; NetFloorArea: 7.74 m2; GrossCeilingArea: 7.74 m2

# IfcSpace: Area:1711992
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.00.05; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 22.285 m2; NetFloorArea: 22.285 m2; GrossCeilingArea: 22.285 m2

# IfcSpace: Area:1712003
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.00.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Keuken
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 7.74 m2; NetFloorArea: 7.74 m2; GrossCeilingArea: 7.74 m2

# IfcSpace: Area:1712005
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; EenheidNummer: 01.00.04; RuimteNummer: 02; RuimteSoort: Subruimte; RuimteType: Woonkamer
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 22.285 m2; NetFloorArea: 22.285 m2; GrossCeilingArea: 22.285 m2

# IfcSpace: Area:1721684
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1388 m2; NetFloorArea: 41.1388 m2; GrossCeilingArea: 41.1388 m2

# IfcSpace: Area:1721687
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.9225 m2; NetFloorArea: 9.9225 m2; GrossCeilingArea: 9.9225 m2

# IfcSpace: Area:1721690
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.8875 m2; NetFloorArea: 22.8875 m2; GrossCeilingArea: 22.8875 m2

# IfcSpace: Area:1721693
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 57.617 m2; NetFloorArea: 57.617 m2; GrossCeilingArea: 57.617 m2

# IfcSpace: Area:1721696
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.43 m2; NetFloorArea: 14.43 m2; GrossCeilingArea: 14.43 m2

# IfcSpace: Area:1721699
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.79625 m2; NetFloorArea: 7.79625 m2; GrossCeilingArea: 7.79625 m2

# IfcSpace: Area:1721702
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721705
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.1288 m2; NetFloorArea: 14.1288 m2; GrossCeilingArea: 14.1288 m2

# IfcSpace: Area:1721708
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 23.43 m2; NetFloorArea: 23.43 m2; GrossCeilingArea: 23.43 m2

# IfcSpace: Area:1721711
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.37125 m2; NetFloorArea: 9.37125 m2; GrossCeilingArea: 9.37125 m2

# IfcSpace: Area:1721714
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1387 m2; NetFloorArea: 41.1387 m2; GrossCeilingArea: 41.1387 m2

# IfcSpace: Area:1721717
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 18.7533 m2; NetFloorArea: 18.7533 m2; GrossCeilingArea: 18.7533 m2

# IfcSpace: Area:1721720
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 54.8345 m2; NetFloorArea: 54.8345 m2; GrossCeilingArea: 54.8345 m2

# IfcSpace: Area:1721723
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 16.4025 m2; NetFloorArea: 16.4025 m2; GrossCeilingArea: 16.4025 m2

# IfcSpace: Area:1721726
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.62825 m2; NetFloorArea: 4.62825 m2; GrossCeilingArea: 4.62825 m2

# IfcSpace: Area:1721729
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721732
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 13.6525 m2; NetFloorArea: 13.6525 m2; GrossCeilingArea: 13.6525 m2

# IfcSpace: Area:1721735
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.08.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.92 m2; NetFloorArea: 22.92 m2; GrossCeilingArea: 22.92 m2

# IfcSpace: Area:1721738
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1721744
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1388 m2; NetFloorArea: 41.1388 m2; GrossCeilingArea: 41.1388 m2

# IfcSpace: Area:1721746
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.9225 m2; NetFloorArea: 9.9225 m2; GrossCeilingArea: 9.9225 m2

# IfcSpace: Area:1721748
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.8875 m2; NetFloorArea: 22.8875 m2; GrossCeilingArea: 22.8875 m2

# IfcSpace: Area:1721750
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 57.617 m2; NetFloorArea: 57.617 m2; GrossCeilingArea: 57.617 m2

# IfcSpace: Area:1721752
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.43 m2; NetFloorArea: 14.43 m2; GrossCeilingArea: 14.43 m2

# IfcSpace: Area:1721754
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.79625 m2; NetFloorArea: 7.79625 m2; GrossCeilingArea: 7.79625 m2

# IfcSpace: Area:1721756
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721758
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.1288 m2; NetFloorArea: 14.1288 m2; GrossCeilingArea: 14.1288 m2

# IfcSpace: Area:1721760
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 23.43 m2; NetFloorArea: 23.43 m2; GrossCeilingArea: 23.43 m2

# IfcSpace: Area:1721762
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.37125 m2; NetFloorArea: 9.37125 m2; GrossCeilingArea: 9.37125 m2

# IfcSpace: Area:1721764
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1387 m2; NetFloorArea: 41.1387 m2; GrossCeilingArea: 41.1387 m2

# IfcSpace: Area:1721766
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 18.7533 m2; NetFloorArea: 18.7533 m2; GrossCeilingArea: 18.7533 m2

# IfcSpace: Area:1721768
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 54.7993 m2; NetFloorArea: 54.7993 m2; GrossCeilingArea: 54.7993 m2

# IfcSpace: Area:1721770
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 16.4025 m2; NetFloorArea: 16.4025 m2; GrossCeilingArea: 16.4025 m2

# IfcSpace: Area:1721772
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.62825 m2; NetFloorArea: 4.62825 m2; GrossCeilingArea: 4.62825 m2

# IfcSpace: Area:1721774
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721776
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 13.6525 m2; NetFloorArea: 13.6525 m2; GrossCeilingArea: 13.6525 m2

# IfcSpace: Area:1721778
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.08.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.92 m2; NetFloorArea: 22.92 m2; GrossCeilingArea: 22.92 m2

# IfcSpace: Area:1721780
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1721787
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1388 m2; NetFloorArea: 41.1388 m2; GrossCeilingArea: 41.1388 m2

# IfcSpace: Area:1721789
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.9225 m2; NetFloorArea: 9.9225 m2; GrossCeilingArea: 9.9225 m2

# IfcSpace: Area:1721791
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.8875 m2; NetFloorArea: 22.8875 m2; GrossCeilingArea: 22.8875 m2

# IfcSpace: Area:1721793
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 57.617 m2; NetFloorArea: 57.617 m2; GrossCeilingArea: 57.617 m2

# IfcSpace: Area:1721795
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.43 m2; NetFloorArea: 14.43 m2; GrossCeilingArea: 14.43 m2

# IfcSpace: Area:1721797
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.79625 m2; NetFloorArea: 7.79625 m2; GrossCeilingArea: 7.79625 m2

# IfcSpace: Area:1721799
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721801
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.1288 m2; NetFloorArea: 14.1288 m2; GrossCeilingArea: 14.1288 m2

# IfcSpace: Area:1721803
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 23.43 m2; NetFloorArea: 23.43 m2; GrossCeilingArea: 23.43 m2

# IfcSpace: Area:1721805
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.37125 m2; NetFloorArea: 9.37125 m2; GrossCeilingArea: 9.37125 m2

# IfcSpace: Area:1721807
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1387 m2; NetFloorArea: 41.1387 m2; GrossCeilingArea: 41.1387 m2

# IfcSpace: Area:1721809
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 18.7533 m2; NetFloorArea: 18.7533 m2; GrossCeilingArea: 18.7533 m2

# IfcSpace: Area:1721811
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 54.8345 m2; NetFloorArea: 54.8345 m2; GrossCeilingArea: 54.8345 m2

# IfcSpace: Area:1721813
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 16.4025 m2; NetFloorArea: 16.4025 m2; GrossCeilingArea: 16.4025 m2

# IfcSpace: Area:1721815
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.62825 m2; NetFloorArea: 4.62825 m2; GrossCeilingArea: 4.62825 m2

# IfcSpace: Area:1721817
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721819
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 13.6525 m2; NetFloorArea: 13.6525 m2; GrossCeilingArea: 13.6525 m2

# IfcSpace: Area:1721821
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.02.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.92 m2; NetFloorArea: 22.92 m2; GrossCeilingArea: 22.92 m2

# IfcSpace: Area:1721823
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1721825
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1388 m2; NetFloorArea: 41.1388 m2; GrossCeilingArea: 41.1388 m2

# IfcSpace: Area:1721827
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.9225 m2; NetFloorArea: 9.9225 m2; GrossCeilingArea: 9.9225 m2

# IfcSpace: Area:1721829
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.8875 m2; NetFloorArea: 22.8875 m2; GrossCeilingArea: 22.8875 m2

# IfcSpace: Area:1721831
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 57.617 m2; NetFloorArea: 57.617 m2; GrossCeilingArea: 57.617 m2

# IfcSpace: Area:1721833
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.43 m2; NetFloorArea: 14.43 m2; GrossCeilingArea: 14.43 m2

# IfcSpace: Area:1721835
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.79625 m2; NetFloorArea: 7.79625 m2; GrossCeilingArea: 7.79625 m2

# IfcSpace: Area:1721837
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721839
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.1288 m2; NetFloorArea: 14.1288 m2; GrossCeilingArea: 14.1288 m2

# IfcSpace: Area:1721841
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 23.43 m2; NetFloorArea: 23.43 m2; GrossCeilingArea: 23.43 m2

# IfcSpace: Area:1721843
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.37125 m2; NetFloorArea: 9.37125 m2; GrossCeilingArea: 9.37125 m2

# IfcSpace: Area:1721845
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1387 m2; NetFloorArea: 41.1387 m2; GrossCeilingArea: 41.1387 m2

# IfcSpace: Area:1721847
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 18.7533 m2; NetFloorArea: 18.7533 m2; GrossCeilingArea: 18.7533 m2

# IfcSpace: Area:1721849
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 54.7993 m2; NetFloorArea: 54.7993 m2; GrossCeilingArea: 54.7993 m2

# IfcSpace: Area:1721851
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 16.4025 m2; NetFloorArea: 16.4025 m2; GrossCeilingArea: 16.4025 m2

# IfcSpace: Area:1721853
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.62825 m2; NetFloorArea: 4.62825 m2; GrossCeilingArea: 4.62825 m2

# IfcSpace: Area:1721855
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721857
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 13.6525 m2; NetFloorArea: 13.6525 m2; GrossCeilingArea: 13.6525 m2

# IfcSpace: Area:1721859
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.02.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.92 m2; NetFloorArea: 22.92 m2; GrossCeilingArea: 22.92 m2

# IfcSpace: Area:1721861
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1721866
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1388 m2; NetFloorArea: 41.1388 m2; GrossCeilingArea: 41.1388 m2

# IfcSpace: Area:1721868
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.9225 m2; NetFloorArea: 9.9225 m2; GrossCeilingArea: 9.9225 m2

# IfcSpace: Area:1721870
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.8875 m2; NetFloorArea: 22.8875 m2; GrossCeilingArea: 22.8875 m2

# IfcSpace: Area:1721872
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 57.617 m2; NetFloorArea: 57.617 m2; GrossCeilingArea: 57.617 m2

# IfcSpace: Area:1721874
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.43 m2; NetFloorArea: 14.43 m2; GrossCeilingArea: 14.43 m2

# IfcSpace: Area:1721876
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.79625 m2; NetFloorArea: 7.79625 m2; GrossCeilingArea: 7.79625 m2

# IfcSpace: Area:1721878
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721880
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.1288 m2; NetFloorArea: 14.1288 m2; GrossCeilingArea: 14.1288 m2

# IfcSpace: Area:1721882
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 23.43 m2; NetFloorArea: 23.43 m2; GrossCeilingArea: 23.43 m2

# IfcSpace: Area:1721884
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.37125 m2; NetFloorArea: 9.37125 m2; GrossCeilingArea: 9.37125 m2

# IfcSpace: Area:1721886
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1387 m2; NetFloorArea: 41.1387 m2; GrossCeilingArea: 41.1387 m2

# IfcSpace: Area:1721888
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 18.7533 m2; NetFloorArea: 18.7533 m2; GrossCeilingArea: 18.7533 m2

# IfcSpace: Area:1721890
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 54.8345 m2; NetFloorArea: 54.8345 m2; GrossCeilingArea: 54.8345 m2

# IfcSpace: Area:1721892
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 16.4025 m2; NetFloorArea: 16.4025 m2; GrossCeilingArea: 16.4025 m2

# IfcSpace: Area:1721894
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.62825 m2; NetFloorArea: 4.62825 m2; GrossCeilingArea: 4.62825 m2

# IfcSpace: Area:1721896
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1721898
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 13.6525 m2; NetFloorArea: 13.6525 m2; GrossCeilingArea: 13.6525 m2

# IfcSpace: Area:1721900
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.03.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.92 m2; NetFloorArea: 22.92 m2; GrossCeilingArea: 22.92 m2

# IfcSpace: Area:1721902
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1721904
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1388 m2; NetFloorArea: 41.1388 m2; GrossCeilingArea: 41.1388 m2

# IfcSpace: Area:1721906
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.9225 m2; NetFloorArea: 9.9225 m2; GrossCeilingArea: 9.9225 m2

# IfcSpace: Area:1721908
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.8875 m2; NetFloorArea: 22.8875 m2; GrossCeilingArea: 22.8875 m2

# IfcSpace: Area:1721910
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.03.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
