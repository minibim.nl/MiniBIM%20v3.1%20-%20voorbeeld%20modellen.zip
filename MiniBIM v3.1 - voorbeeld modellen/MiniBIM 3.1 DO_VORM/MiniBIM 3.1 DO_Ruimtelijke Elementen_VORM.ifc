Properties of the parts of a building model (IFC4), part 12 of 12

# IfcSpace: Area:1747796
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 19.8087 m2; NetFloorArea: 19.8087 m2; GrossCeilingArea: 19.8087 m2

# IfcSpace: Area:1747798
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.675 m2; NetFloorArea: 4.675 m2; GrossCeilingArea: 4.675 m2

# IfcSpace: Area:1747800
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 64.0525 m2; NetFloorArea: 64.0525 m2; GrossCeilingArea: 64.0525 m2

# IfcSpace: Area:1747802
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 19.8087 m2; NetFloorArea: 19.8087 m2; GrossCeilingArea: 19.8087 m2

# IfcSpace: Area:1747804
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.675 m2; NetFloorArea: 4.675 m2; GrossCeilingArea: 4.675 m2

# IfcSpace: Area:1747806
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 64.0525 m2; NetFloorArea: 64.0525 m2; GrossCeilingArea: 64.0525 m2

# IfcSpace: Area:1747808
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.4408 m2; NetFloorArea: 15.4408 m2; GrossCeilingArea: 15.4408 m2

# IfcSpace: Area:1747810
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.675 m2; NetFloorArea: 4.675 m2; GrossCeilingArea: 4.675 m2

# IfcSpace: Area:1747812
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 64.0525 m2; NetFloorArea: 64.0525 m2; GrossCeilingArea: 64.0525 m2

# IfcSpace: Area:1747814
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1748313
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 148.254 m2; NetFloorArea: 142.896 m2; GrossCeilingArea: 148.254 m2

# IfcSpace: Area:1748340
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijk verblijfsgebied; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 73.1081 m2; NetFloorArea: 73.1081 m2; GrossCeilingArea: 73.1081 m2

# IfcSpace: Area:1748362
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 98.925 m2; NetFloorArea: 98.925 m2; GrossCeilingArea: 98.925 m2

# IfcSpace: Area:1748378
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 100.125 m2; NetFloorArea: 100.125 m2; GrossCeilingArea: 100.125 m2

# IfcSpace: Area:1748389
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 127.908 m2; NetFloorArea: 127.908 m2; GrossCeilingArea: 127.908 m2

# IfcSpace: Area:1748391
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijk verblijfsgebied; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 73.1081 m2; NetFloorArea: 73.1081 m2; GrossCeilingArea: 73.1081 m2

# IfcSpace: Area:1748393
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 98.925 m2; NetFloorArea: 98.925 m2; GrossCeilingArea: 98.925 m2

# IfcSpace: Area:1748518
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie, Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 14.4919 m2; NetFloorArea: 14.4919 m2; GrossCeilingArea: 14.4919 m2

# IfcSpace: Area:1759840
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1759847
In: 02 tweede verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1759850
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1759851
In: 03 derde verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1759854
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1759855
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1759858
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1759859
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1759862
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1759863
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1759866
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1759867
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1759870
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1759871
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1760089
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1760090
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1762312
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Fietsenstalling inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 99.175 m2; NetFloorArea: 99.175 m2; GrossCeilingArea: 99.175 m2

# IfcSpace: Area:1762315
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijk verblijfsgebied; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijk verblijfsgebied; GebiedsType: Huiskamer; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 72.8625 m2; NetFloorArea: 72.8625 m2; GrossCeilingArea: 72.8625 m2

# IfcSpace: Area:1762318
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Parkeergarage stalling; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 18.7965 m2; NetFloorArea: 18.7965 m2; GrossCeilingArea: 18.7965 m2

# IfcSpace: Area:1762321
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 134.708 m2; NetFloorArea: 132.26 m2; GrossCeilingArea: 134.708 m2

# IfcSpace: Area:1762327
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Fietsenstalling inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 99.175 m2; NetFloorArea: 99.175 m2; GrossCeilingArea: 99.175 m2

# IfcSpace: Area:1762329
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijk verblijfsgebied; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijk verblijfsgebied; GebiedsType: Huiskamer; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 72.8625 m2; NetFloorArea: 72.8625 m2; GrossCeilingArea: 72.8625 m2

# IfcSpace: Area:1762331
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 119.736 m2; NetFloorArea: 117.288 m2; GrossCeilingArea: 119.736 m2

# IfcSpace: Area:1762346
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie, Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 15.1403 m2; NetFloorArea: 15.1403 m2; GrossCeilingArea: 15.1403 m2

# IfcSpace: Area:1767419
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Techniekruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 8.45625 m2; NetFloorArea: 8.45625 m2; GrossCeilingArea: 8.45625 m2

# IfcSpace: Area:1767422
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 00; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Techniekruimte; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 9.12 m2; NetFloorArea: 9.12 m2; GrossCeilingArea: 9.12 m2

# IfcSpace: Area:1767425
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Techniekruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 8.45625 m2; NetFloorArea: 8.45625 m2; GrossCeilingArea: 8.45625 m2

# IfcSpace: Area:1767428
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Techniekruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 4.7115 m2; NetFloorArea: 4.7115 m2; GrossCeilingArea: 4.7115 m2

# IfcSpace: Area:1767431
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Techniekruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 4.7115 m2; NetFloorArea: 4.7115 m2; GrossCeilingArea: 4.7115 m2

# IfcSpace: Area:1767434
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 00; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Techniekruimte; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 8.64 m2; NetFloorArea: 8.64 m2; GrossCeilingArea: 8.64 m2

# IfcSpace: Area:1767437
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Restgebied; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 00; GebiedsSoort: Nevengebruiksfunctie; GebiedsType: Berging inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 24.2288 m2; NetFloorArea: 24.2288 m2; GrossCeilingArea: 24.2288 m2

# IfcSpace: Area:1767440
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Restgebied; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 00; GebiedsSoort: Nevengebruiksfunctie; GebiedsType: Berging inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 40.6088 m2; NetFloorArea: 40.6088 m2; GrossCeilingArea: 40.6088 m2

# IfcSpace: Area:1767443
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Restgebied; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 00; GebiedsSoort: Nevengebruiksfunctie; GebiedsType: Berging inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 54.2937 m2; NetFloorArea: 54.2937 m2; GrossCeilingArea: 54.2937 m2

# IfcSpace: Area:1767446
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Restgebied; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 00; GebiedsSoort: Nevengebruiksfunctie; GebiedsType: Berging inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 58.1612 m2; NetFloorArea: 58.1612 m2; GrossCeilingArea: 58.1612 m2

# IfcSpace: Area:1767449
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 33.0705 m2; NetFloorArea: 31.4865 m2; GrossCeilingArea: 33.0705 m2

# IfcSpace: Area:1767452
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 00; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Fietsenstalling inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 141.488 m2; NetFloorArea: 141.488 m2; GrossCeilingArea: 141.488 m2

# IfcSpace: Area:1767455
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 00; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Fietsenstalling inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 141.488 m2; NetFloorArea: 141.488 m2; GrossCeilingArea: 141.488 m2

# IfcSpace: Area:1767458
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Techniekruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 5.3055 m2; NetFloorArea: 5.3055 m2; GrossCeilingArea: 5.3055 m2

# IfcSpace: Area:1767461
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Techniekruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 5.3055 m2; NetFloorArea: 5.3055 m2; GrossCeilingArea: 5.3055 m2

# IfcSpace: Area:1767464
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Techniekruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 8.45625 m2; NetFloorArea: 8.45625 m2; GrossCeilingArea: 8.45625 m2

# IfcSpace: Area:1767467
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Techniekruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 8.45625 m2; NetFloorArea: 8.45625 m2; GrossCeilingArea: 8.45625 m2

# IfcSpace: Area:1767470
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 31.651 m2; NetFloorArea: 30.243 m2; GrossCeilingArea: 31.651 m2

# IfcSpace: Area:1767473
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 00; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Parkeergarage stalling; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 1809.29 m2; NetFloorArea: 1718.15 m2; GrossCeilingArea: 1809.29 m2

# IfcSpace: Area:1767543
In: -1 kelder
Type - PredefinedType: USERDEFINED
LongName: Gemeenschappelijke ruimte; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Gemeenschappelijk; Bepalingsmethode: GO; BouwwerkNummer: 00; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 64.0725 m2; NetFloorArea: 64.0725 m2; GrossCeilingArea: 64.0725 m2

# IfcSpace: Bouwwerk 00:Bouwwerk 00, Bouwwerk 00
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset_SpaceCommon - IsExternal: no; Reference: Bouwwerk 00
Pset_SpaceHeaterTypeCommon - Reference: Bouwwerk 00
MiniBIM ILS - Bepalingsmethode: BI; BouwwerkNummer: 00; BouwwerkType: Stallinggebouw
Qto_SpaceBaseQuantities - GrossCeilingArea: 2355.09 m2; GrossVolume: 7749.01 m3; NetVolume: 7749.01 m3
Group: 00

# IfcSpace: Bouwwerk 01:Bouwwerk 01, Bouwwerk 01
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset_SpaceCommon - IsExternal: no; Reference: Bouwwerk 01
Pset_SpaceHeaterTypeCommon - Reference: Bouwwerk 01
MiniBIM ILS - Bepalingsmethode: BI; BouwwerkNummer: 01; BouwwerkType: Woongebouw
Qto_SpaceBaseQuantities - GrossCeilingArea: 2215.52 m2; GrossVolume: 18171.1 m3; NetVolume: 18171.1 m3
Group: 01

# IfcSpace: Bouwwerk 02:Bouwwerk 02, Bouwwerk 02
Type - PredefinedType: USERDEFINED; Material: <Unnamed>
Pset_SpaceCommon - IsExternal: no; Reference: Bouwwerk 02
Pset_SpaceHeaterTypeCommon - Reference: Bouwwerk 02
MiniBIM ILS - Bepalingsmethode: BI; BouwwerkNummer: 02; BouwwerkType: Woongebouw
Qto_SpaceBaseQuantities - GrossCeilingArea: 2215.52 m2; GrossVolume: 18171.1 m3; NetVolume: 18171.1 m3
Group: 02
