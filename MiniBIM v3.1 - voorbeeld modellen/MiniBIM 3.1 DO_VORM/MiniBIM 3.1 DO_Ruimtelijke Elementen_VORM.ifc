Properties of the parts of a building model (IFC4), part 4 of 12

# IfcSpace: 02.04.04 (11)
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.04.04 | Slaapkamer | A 383 | 04 | Verblijfsruimte | 13.65 | 37.5375 | 37.5375 | MiniBIM ILS - Orientatie: Oost
02.04.04 | Bergruimte | A 384 | 09 | Restruimte | 1.78875 | 4.91906 | 4.91906
02.04.04 | Toiletruimte | A 385 | 10 | Restruimte | 1.1875 | 3.26563 | 3.26563
02.04.04 | Schacht | A 386 | 11 | Restruimte | 0.34375 | 1.03125 | 1.03125
02.04.04 | Entree | A 387 | 01 | Restruimte | 4.455 | 12.2513 | 12.2513
02.04.04 | Bergruimte | A 388 | 07 | Restruimte | 2.1 | 5.775 | 5.775
02.04.04 | Bergruimte | A 389 | 06 | Restruimte | 3.15 | 8.6625 | 8.6625
02.04.04 | Gang | A 390 | 08 | Restruimte | 4.235 |  | 11.6463

# IfcSpace: 02.04.04 (2)
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.04.04; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.04.04
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.04.04 | Gebruiksfunctie | GO | 81.4275 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: I
02.04.04 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.04.05 (8)
In: 04 vierde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.04.05
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.04.05 | Woonkamer-keuken | A 135 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | 85.1916 | MiniBIM ILS - Orientatie: Zuid, Oost
02.04.05 | Slaapkamer | A 136 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | 21.8281 | MiniBIM ILS - Orientatie: Zuid
02.04.05 | Slaapkamer | A 137 | 02 | Verblijfsruimte | 14.1287 | 38.8541 | 38.8541 | MiniBIM ILS - Orientatie: Zuid
02.04.05 | Badruimte | A 138 | 05 | Restruimte | 5.5 | 15.125 | 15.125
02.04.05 | Bergruimte | A 139 | 06 | Restruimte | 4.5025 | 12.3819 | 12.3819
02.04.05 | Toiletruimte | A 140 | 07 | Restruimte | 1.1875 |  | 3.26563
02.04.05 | Schacht | A 141 | 08 | Restruimte | 0.255 | 0.765 | 0.765
02.04.05 | Entree | A 142 | 01 | Restruimte | 11.365 |  | 31.2538

# IfcSpace: 02.04.05 (2)
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.04.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.04.05
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.04.05 | Gebruiksfunctie | GO | Zuid, Oost | 78.3725 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: H
02.04.05 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.04.06 (8)
In: 04 vierde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.04.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.04.06
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.04.06 | Woonkamer-keuken | A 247 | 04 | Verblijfsruimte | 26.6437 | 73.2703 | 73.2703 | MiniBIM ILS - Orientatie: Zuid, West
02.04.06 | Slaapkamer | A 248 | 03 | Verblijfsruimte | 9.37125 |  | 25.7709 | MiniBIM ILS - Orientatie: Zuid
02.04.06 | Slaapkamer | A 249 | 03 | Verblijfsruimte | 13.975 | 38.4313 | 38.4313 | MiniBIM ILS - Orientatie: West
02.04.06 | Entree | A 250 | 01 | Restruimte | 10.7332 | 29.5164 | 29.5164
02.04.06 | Bergruimte | A 251 | 06 | Restruimte | 2.0925 | 5.75437 | 5.75437
02.04.06 | Toiletruimte | A 252 | 07 | Restruimte | 1.1875 |  | 3.26563
02.04.06 | Badruimte | A 253 | 05 | Restruimte | 4.16 |  | 11.44
02.04.06 | Schacht | A 254 | 08 | Restruimte | 0.375 | 1.125 | 1.125

# IfcSpace: 02.04.06 (2)
In: 04 vierde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.04.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.04.06
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.04.06 | Gebruiksfunctie | GO | Zuid, West | 70.6182 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: G
02.04.06 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.05.01 (9)
In: 05 vijfde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.05.01
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.05.01 | Slaapkamer | A 529 | 05 | Verblijfsruimte | 13.65 | 37.5375 | 37.5375 | MiniBIM ILS - Orientatie: West
02.05.01 | Slaapkamer | A 530 | 04 | Verblijfsruimte | 8.575 | 23.5813 | 23.5813 | MiniBIM ILS - Orientatie: West
02.05.01 | Woonkamer-keuken | A 531 | 02 | Verblijfsruimte | 31.9 | 87.725 | 87.725 | MiniBIM ILS - Orientatie: West
02.05.01 | Badruimte | A 532 | 06 | Restruimte | 4.16 |  | 11.44
02.05.01 | Toiletruimte | A 533 | 08 | Restruimte | 1.1875 |  | 3.26562
02.05.01 | Schacht | A 534 | 09 | Restruimte | 0.42 | 1.26 | 1.26
02.05.01 | Entree | A 535 | 01 | Restruimte | 4.62825 |  | 12.7277
02.05.01 | Gang | A 536 | 03 | Restruimte | 5.39 |  | 14.8225
02.05.01 | Bergruimte | A 537 | 07 | Restruimte | 4.83 | 13.2825 | 13.2825

# IfcSpace: 02.05.01 (2)
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.05.01; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.05.01
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.05.01 | Gebruiksfunctie | GO | 77.7495 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: F
02.05.01 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.05.02 (8)
In: 05 vijfde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.05.02
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
02.05.02 | Woonkamer-keuken | A 773 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Noord, West; Qto_SpaceBaseQuantities - GrossVolume: 85.1916 m3
02.05.02 | Slaapkamer | A 774 | 02 | Verblijfsruimte | 13.6525 | 37.5444 | MiniBIM ILS - Orientatie: Noord
02.05.02 | Slaapkamer | A 775 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | MiniBIM ILS - Orientatie: Noord
02.05.02 | Badruimte | A 776 | 05 | Restruimte | 5.5 | 15.125 | Qto_SpaceBaseQuantities - GrossVolume: 15.125 m3
02.05.02 | Toiletruimte | A 777 | 07 | Restruimte | 1.1875 | 3.26562
02.05.02 | Bergruimte | A 778 | 06 | Restruimte | 4.1527 | 11.4199
02.05.02 | Schacht | A 779 | 08 | Restruimte | 0.255 | 0.765 | Qto_SpaceBaseQuantities - GrossVolume: 0.765 m3
02.05.02 | Entree | A 780 | 01 | Restruimte | 11.2207 | 30.8569

# IfcSpace: 02.05.02 (2)
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.05.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.05.02
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.05.02 | Gebruiksfunctie | GO | Noord, West | 77.3712 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: E
02.05.02 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.05.03 (9)
In: 05 vijfde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.05.03
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.05.03 | Woonkamer-keuken | A 655 | 07 | Verblijfsruimte | 26.6437 | 73.2703 | 73.2703 | MiniBIM ILS - Orientatie: Noord, Oost
02.05.03 | Slaapkamer | A 656 | 06 | Verblijfsruimte | 13.975 | 38.4313 | 38.4313 | MiniBIM ILS - Orientatie: Oost
02.05.03 | Slaapkamer | A 657 | 08 | Verblijfsruimte | 9.9225 | 27.2869 | 27.2869 | MiniBIM ILS - Orientatie: Noord
02.05.03 | Bergruimte | A 658 | 09 | Restruimte | 4.06 |  | 11.165
02.05.03 | Badruimte | A 659 | 05 | Restruimte | 4.16 | 11.44 | 11.44
02.05.03 | Toiletruimte | A 660 | 03 | Restruimte | 1.1875 | 3.26563 | 3.26563
02.05.03 | Schacht | A 661 | 04 | Restruimte | 0.375 | 1.125 | 1.125
02.05.03 | Bergruimte | A 662 | 02 | Restruimte | 1.8225 | 5.01187 | 5.01187
02.05.03 | Entree | A 663 | 01 | Restruimte | 10.8075 | 29.7206 | 29.7206

# IfcSpace: 02.05.03 (2)
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.05.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.05.03
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.05.03 | Gebruiksfunctie | GO | Noord, Oost | 75.3187 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: J
02.05.03 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.05.04 (11)
In: 05 vijfde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.05.04
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.05.04 | Woonkamer-keuken | A 391 | 02 | Verblijfsruimte | 31.9 | 87.725 | 87.725 | MiniBIM ILS - Orientatie: Oost
02.05.04 | Badruimte | A 392 | 05 | Restruimte | 4.16 | 11.44 | 11.44
02.05.04 | Slaapkamer | A 393 | 03 | Verblijfsruimte | 11.1475 | 30.6556 | 30.6556 | MiniBIM ILS - Orientatie: Oost
02.05.04 | Slaapkamer | A 394 | 04 | Verblijfsruimte | 13.65 | 37.5375 | 37.5375 | MiniBIM ILS - Orientatie: Oost
02.05.04 | Bergruimte | A 395 | 09 | Restruimte | 1.78875 | 4.91906 | 4.91906
02.05.04 | Toiletruimte | A 396 | 10 | Restruimte | 1.1875 | 3.26563 | 3.26563
02.05.04 | Schacht | A 397 | 11 | Restruimte | 0.34375 | 1.03125 | 1.03125
02.05.04 | Entree | A 398 | 01 | Restruimte | 4.455 | 12.2513 | 12.2513
02.05.04 | Bergruimte | A 399 | 07 | Restruimte | 2.1 | 5.775 | 5.775
02.05.04 | Bergruimte | A 400 | 06 | Restruimte | 3.15 | 8.6625 | 8.6625
02.05.04 | Gang | A 401 | 08 | Restruimte | 4.235 |  | 11.6463

# IfcSpace: 02.05.04 (2)
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.05.04; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.05.04
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.05.04 | Gebruiksfunctie | GO | 81.4275 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: I
02.05.04 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.05.05 (8)
In: 05 vijfde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.05.05
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.05.05 | Woonkamer-keuken | A 143 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | 85.1916 | MiniBIM ILS - Orientatie: Zuid, Oost
02.05.05 | Slaapkamer | A 144 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | 21.8281 | MiniBIM ILS - Orientatie: Zuid
02.05.05 | Slaapkamer | A 145 | 02 | Verblijfsruimte | 14.1287 | 38.8541 | 38.8541 | MiniBIM ILS - Orientatie: Zuid
02.05.05 | Badruimte | A 146 | 05 | Restruimte | 5.5 | 15.125 | 15.125
02.05.05 | Bergruimte | A 147 | 06 | Restruimte | 4.5025 | 12.3819 | 12.3819
02.05.05 | Toiletruimte | A 148 | 07 | Restruimte | 1.1875 |  | 3.26563
02.05.05 | Schacht | A 149 | 08 | Restruimte | 0.255 | 0.765 | 0.765
02.05.05 | Entree | A 150 | 01 | Restruimte | 11.365 |  | 31.2538

# IfcSpace: 02.05.05 (2)
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.05.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.05.05
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.05.05 | Gebruiksfunctie | GO | Zuid, Oost | 78.3725 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: H
02.05.05 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.05.06 (8)
In: 05 vijfde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.05.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.05.06
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.05.06 | Woonkamer-keuken | A 255 | 04 | Verblijfsruimte | 26.6437 | 73.2703 | 73.2703 | MiniBIM ILS - Orientatie: Zuid, West
02.05.06 | Slaapkamer | A 256 | 03 | Verblijfsruimte | 9.37125 |  | 25.7709 | MiniBIM ILS - Orientatie: Zuid
02.05.06 | Slaapkamer | A 257 | 03 | Verblijfsruimte | 13.975 | 38.4313 | 38.4313 | MiniBIM ILS - Orientatie: West
02.05.06 | Entree | A 258 | 01 | Restruimte | 10.7332 | 29.5164 | 29.5164
02.05.06 | Bergruimte | A 259 | 06 | Restruimte | 2.0925 | 5.75437 | 5.75437
02.05.06 | Toiletruimte | A 260 | 07 | Restruimte | 1.1875 |  | 3.26563
02.05.06 | Badruimte | A 261 | 05 | Restruimte | 4.16 |  | 11.44
02.05.06 | Schacht | A 262 | 08 | Restruimte | 0.375 | 1.125 | 1.125

# IfcSpace: 02.05.06 (2)
In: 05 vijfde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.05.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.05.06
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.05.06 | Gebruiksfunctie | GO | Zuid, West | 70.6182 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: G
02.05.06 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.06.01 (9)
In: 06 zesde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.06.01
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.06.01 | Slaapkamer | A 538 | 05 | Verblijfsruimte | 13.65 | 37.5375 | 37.5375 | MiniBIM ILS - Orientatie: West
02.06.01 | Slaapkamer | A 539 | 04 | Verblijfsruimte | 8.575 | 23.5813 | 23.5813 | MiniBIM ILS - Orientatie: West
02.06.01 | Woonkamer-keuken | A 540 | 02 | Verblijfsruimte | 31.9 | 87.725 | 87.725 | MiniBIM ILS - Orientatie: West
02.06.01 | Badruimte | A 541 | 06 | Restruimte | 4.16 |  | 11.44
02.06.01 | Toiletruimte | A 542 | 08 | Restruimte | 1.1875 |  | 3.26562
02.06.01 | Schacht | A 543 | 09 | Restruimte | 0.42 | 1.26 | 1.26
02.06.01 | Entree | A 544 | 01 | Restruimte | 4.62825 |  | 12.7277
02.06.01 | Gang | A 545 | 03 | Restruimte | 5.39 |  | 14.8225
02.06.01 | Bergruimte | A 546 | 07 | Restruimte | 4.83 | 13.2825 | 13.2825

# IfcSpace: 02.06.01 (2)
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.06.01; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.06.01
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.06.01 | Gebruiksfunctie | GO | 77.7495 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: F
02.06.01 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.06.02 (8)
In: 06 zesde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.06.02
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
02.06.02 | Woonkamer-keuken | A 781 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Noord, West; Qto_SpaceBaseQuantities - GrossVolume: 85.1916 m3
02.06.02 | Slaapkamer | A 782 | 02 | Verblijfsruimte | 13.6525 | 37.5444 | MiniBIM ILS - Orientatie: Noord
02.06.02 | Slaapkamer | A 783 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | MiniBIM ILS - Orientatie: Noord
02.06.02 | Badruimte | A 784 | 05 | Restruimte | 5.5 | 15.125 | Qto_SpaceBaseQuantities - GrossVolume: 15.125 m3
02.06.02 | Toiletruimte | A 785 | 07 | Restruimte | 1.1875 | 3.26562
02.06.02 | Bergruimte | A 786 | 06 | Restruimte | 4.1527 | 11.4199
02.06.02 | Schacht | A 787 | 08 | Restruimte | 0.255 | 0.765 | Qto_SpaceBaseQuantities - GrossVolume: 0.765 m3
02.06.02 | Entree | A 788 | 01 | Restruimte | 11.2207 | 30.8569

# IfcSpace: 02.06.02 (2)
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.06.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.06.02
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.06.02 | Gebruiksfunctie | GO | Noord, West | 77.3712 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: E
02.06.02 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.06.03 (9)
In: 06 zesde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.06.03
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.06.03 | Woonkamer-keuken | A 664 | 07 | Verblijfsruimte | 26.6437 | 73.2703 | 73.2703 | MiniBIM ILS - Orientatie: Noord, Oost
02.06.03 | Slaapkamer | A 665 | 06 | Verblijfsruimte | 13.975 | 38.4313 | 38.4313 | MiniBIM ILS - Orientatie: Oost
02.06.03 | Slaapkamer | A 666 | 08 | Verblijfsruimte | 9.9225 | 27.2869 | 27.2869 | MiniBIM ILS - Orientatie: Noord
02.06.03 | Bergruimte | A 667 | 09 | Restruimte | 4.06 |  | 11.165
02.06.03 | Badruimte | A 668 | 05 | Restruimte | 4.16 | 11.44 | 11.44
02.06.03 | Toiletruimte | A 669 | 03 | Restruimte | 1.1875 | 3.26563 | 3.26563
02.06.03 | Schacht | A 670 | 04 | Restruimte | 0.375 | 1.125 | 1.125
02.06.03 | Bergruimte | A 671 | 02 | Restruimte | 1.8225 | 5.01187 | 5.01187
02.06.03 | Entree | A 672 | 01 | Restruimte | 10.8075 | 29.7206 | 29.7206

# IfcSpace: 02.06.03 (2)
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.06.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.06.03
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.06.03 | Gebruiksfunctie | GO | Noord, Oost | 75.3187 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: J
02.06.03 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.06.04 (11)
In: 06 zesde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.06.04
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.06.04 | Woonkamer-keuken | A 402 | 02 | Verblijfsruimte | 31.9 | 87.725 | 87.725 | MiniBIM ILS - Orientatie: Oost
02.06.04 | Badruimte | A 403 | 05 | Restruimte | 4.16 | 11.44 | 11.44
02.06.04 | Slaapkamer | A 404 | 03 | Verblijfsruimte | 11.1475 | 30.6556 | 30.6556 | MiniBIM ILS - Orientatie: Oost
02.06.04 | Slaapkamer | A 405 | 04 | Verblijfsruimte | 13.65 | 37.5375 | 37.5375 | MiniBIM ILS - Orientatie: Oost
02.06.04 | Bergruimte | A 406 | 09 | Restruimte | 1.78875 | 4.91906 | 4.91906
02.06.04 | Toiletruimte | A 407 | 10 | Restruimte | 1.1875 | 3.26563 | 3.26563
02.06.04 | Schacht | A 408 | 11 | Restruimte | 0.34375 | 1.03125 | 1.03125
02.06.04 | Entree | A 409 | 01 | Restruimte | 4.455 | 12.2513 | 12.2513
02.06.04 | Bergruimte | A 410 | 07 | Restruimte | 2.1 | 5.775 | 5.775
02.06.04 | Bergruimte | A 411 | 06 | Restruimte | 3.15 | 8.6625 | 8.6625
02.06.04 | Gang | A 412 | 08 | Restruimte | 4.235 |  | 11.6463

# IfcSpace: 02.06.04 (2)
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.06.04; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.06.04
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.06.04 | Gebruiksfunctie | GO | 81.4275 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: I
02.06.04 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.06.05 (8)
In: 06 zesde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.06.05
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.06.05 | Woonkamer-keuken | A 151 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | 85.1916 | MiniBIM ILS - Orientatie: Zuid, Oost
02.06.05 | Slaapkamer | A 152 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | 21.8281 | MiniBIM ILS - Orientatie: Zuid
02.06.05 | Slaapkamer | A 153 | 02 | Verblijfsruimte | 14.1287 | 38.8541 | 38.8541 | MiniBIM ILS - Orientatie: Zuid
02.06.05 | Badruimte | A 154 | 05 | Restruimte | 5.5 | 15.125 | 15.125
02.06.05 | Bergruimte | A 155 | 06 | Restruimte | 4.5025 | 12.3819 | 12.3819
02.06.05 | Toiletruimte | A 156 | 07 | Restruimte | 1.1875 |  | 3.26563
02.06.05 | Schacht | A 157 | 08 | Restruimte | 0.255 | 0.765 | 0.765
02.06.05 | Entree | A 158 | 01 | Restruimte | 11.365 |  | 31.2538

# IfcSpace: 02.06.05 (2)
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.06.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.06.05
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.06.05 | Gebruiksfunctie | GO | Zuid, Oost | 78.3725 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: H
02.06.05 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.06.06 (8)
In: 06 zesde verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.06.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.06.06
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.06.06 | Woonkamer-keuken | A 263 | 04 | Verblijfsruimte | 26.6437 | 73.2703 | 73.2703 | MiniBIM ILS - Orientatie: Zuid, West
02.06.06 | Slaapkamer | A 264 | 03 | Verblijfsruimte | 9.37125 |  | 25.7709 | MiniBIM ILS - Orientatie: Zuid
02.06.06 | Slaapkamer | A 265 | 03 | Verblijfsruimte | 13.975 | 38.4313 | 38.4313 | MiniBIM ILS - Orientatie: West
02.06.06 | Entree | A 266 | 01 | Restruimte | 10.7332 | 29.5164 | 29.5164
02.06.06 | Bergruimte | A 267 | 06 | Restruimte | 2.0925 | 5.75437 | 5.75437
02.06.06 | Toiletruimte | A 268 | 07 | Restruimte | 1.1875 |  | 3.26563
02.06.06 | Badruimte | A 269 | 05 | Restruimte | 4.16 |  | 11.44
02.06.06 | Schacht | A 270 | 08 | Restruimte | 0.375 | 1.125 | 1.125

# IfcSpace: 02.06.06 (2)
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.06.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.06.06
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.06.06 | Gebruiksfunctie | GO | Zuid, West | 70.6182 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: G
02.06.06 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.07.01 (9)
In: 07 zevende verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.07.01
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.07.01 | Slaapkamer | A 556 | 05 | Verblijfsruimte | 13.65 | 37.5375 | 37.5375 | MiniBIM ILS - Orientatie: West
02.07.01 | Slaapkamer | A 557 | 04 | Verblijfsruimte | 8.575 | 23.5813 | 23.5813 | MiniBIM ILS - Orientatie: West
02.07.01 | Woonkamer-keuken | A 558 | 02 | Verblijfsruimte | 31.9 | 87.725 | 87.725 | MiniBIM ILS - Orientatie: West
02.07.01 | Badruimte | A 559 | 06 | Restruimte | 4.16 |  | 11.44
02.07.01 | Toiletruimte | A 560 | 08 | Restruimte | 1.1875 |  | 3.26562
02.07.01 | Schacht | A 561 | 09 | Restruimte | 0.42 | 1.26 | 1.26
02.07.01 | Entree | A 562 | 01 | Restruimte | 4.62825 |  | 12.7277
02.07.01 | Gang | A 563 | 03 | Restruimte | 5.39 |  | 14.8225
02.07.01 | Bergruimte | A 564 | 07 | Restruimte | 4.83 | 13.2825 | 13.2825

# IfcSpace: 02.07.01 (2)
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.07.01; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.07.01
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.07.01 | Gebruiksfunctie | GO | 77.7495 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: F
02.07.01 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.07.02 (8)
In: 07 zevende verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.07.02
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
02.07.02 | Woonkamer-keuken | A 797 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Noord, West; Qto_SpaceBaseQuantities - GrossVolume: 85.1916 m3
02.07.02 | Slaapkamer | A 798 | 02 | Verblijfsruimte | 13.6525 | 37.5444 | MiniBIM ILS - Orientatie: Noord
02.07.02 | Slaapkamer | A 799 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | MiniBIM ILS - Orientatie: Noord
02.07.02 | Badruimte | A 800 | 05 | Restruimte | 5.5 | 15.125 | Qto_SpaceBaseQuantities - GrossVolume: 15.125 m3
02.07.02 | Toiletruimte | A 801 | 07 | Restruimte | 1.1875 | 3.26562
02.07.02 | Bergruimte | A 802 | 06 | Restruimte | 4.1527 | 11.4199
02.07.02 | Schacht | A 803 | 08 | Restruimte | 0.255 | 0.765 | Qto_SpaceBaseQuantities - GrossVolume: 0.765 m3
02.07.02 | Entree | A 804 | 01 | Restruimte | 11.2207 | 30.8569

# IfcSpace: 02.07.02 (2)
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.07.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.07.02
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.07.02 | Gebruiksfunctie | GO | Noord, West | 77.3712 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: E
02.07.02 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.07.03 (9)
In: 07 zevende verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.07.03
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.07.03 | Woonkamer-keuken | A 682 | 07 | Verblijfsruimte | 26.6437 | 73.2703 | 73.2703 | MiniBIM ILS - Orientatie: Noord, Oost
02.07.03 | Slaapkamer | A 683 | 06 | Verblijfsruimte | 13.975 | 38.4313 | 38.4313 | MiniBIM ILS - Orientatie: Oost
02.07.03 | Slaapkamer | A 684 | 08 | Verblijfsruimte | 9.9225 | 27.2869 | 27.2869 | MiniBIM ILS - Orientatie: Noord
02.07.03 | Bergruimte | A 685 | 09 | Restruimte | 4.06 |  | 11.165
02.07.03 | Badruimte | A 686 | 05 | Restruimte | 4.16 | 11.44 | 11.44
02.07.03 | Toiletruimte | A 687 | 03 | Restruimte | 1.1875 | 3.26563 | 3.26563
02.07.03 | Schacht | A 688 | 04 | Restruimte | 0.375 | 1.125 | 1.125
02.07.03 | Bergruimte | A 689 | 02 | Restruimte | 1.8225 | 5.01187 | 5.01187
02.07.03 | Entree | A 690 | 01 | Restruimte | 10.8075 | 29.7206 | 29.7206

# IfcSpace: 02.07.03 (2)
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.07.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.07.03
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.07.03 | Gebruiksfunctie | GO | Noord, Oost | 75.3187 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: J
02.07.03 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.07.04 (11)
In: 07 zevende verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.07.04
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.07.04 | Woonkamer-keuken | A 424 | 02 | Verblijfsruimte | 31.9 | 87.725 | 87.725 | MiniBIM ILS - Orientatie: Oost
02.07.04 | Badruimte | A 425 | 05 | Restruimte | 4.16 | 11.44 | 11.44
02.07.04 | Slaapkamer | A 426 | 03 | Verblijfsruimte | 11.1475 | 30.6556 | 30.6556 | MiniBIM ILS - Orientatie: Oost
02.07.04 | Slaapkamer | A 427 | 04 | Verblijfsruimte | 13.65 | 37.5375 | 37.5375 | MiniBIM ILS - Orientatie: Oost
02.07.04 | Bergruimte | A 428 | 09 | Restruimte | 1.78875 | 4.91906 | 4.91906
02.07.04 | Toiletruimte | A 429 | 10 | Restruimte | 1.1875 | 3.26563 | 3.26563
02.07.04 | Schacht | A 430 | 11 | Restruimte | 0.34375 | 1.03125 | 1.03125
02.07.04 | Entree | A 431 | 01 | Restruimte | 4.455 | 12.2513 | 12.2513
02.07.04 | Bergruimte | A 432 | 07 | Restruimte | 2.1 | 5.775 | 5.775
02.07.04 | Bergruimte | A 433 | 06 | Restruimte | 3.15 | 8.6625 | 8.6625
02.07.04 | Gang | A 434 | 08 | Restruimte | 4.235 |  | 11.6463

# IfcSpace: 02.07.04 (2)
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.07.04; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.07.04
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.07.04 | Gebruiksfunctie | GO | 81.4275 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: I
02.07.04 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.07.05 (8)
In: 07 zevende verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.07.05
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.07.05 | Woonkamer-keuken | A 167 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | 85.1916 | MiniBIM ILS - Orientatie: Zuid, Oost
02.07.05 | Slaapkamer | A 168 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | 21.8281 | MiniBIM ILS - Orientatie: Zuid
02.07.05 | Slaapkamer | A 169 | 02 | Verblijfsruimte | 14.1287 | 38.8541 | 38.8541 | MiniBIM ILS - Orientatie: Zuid
02.07.05 | Badruimte | A 170 | 05 | Restruimte | 5.5 | 15.125 | 15.125
02.07.05 | Bergruimte | A 171 | 06 | Restruimte | 4.5025 | 12.3819 | 12.3819
02.07.05 | Toiletruimte | A 172 | 07 | Restruimte | 1.1875 |  | 3.26563
02.07.05 | Schacht | A 173 | 08 | Restruimte | 0.255 | 0.765 | 0.765
02.07.05 | Entree | A 174 | 01 | Restruimte | 11.365 |  | 31.2538

# IfcSpace: 02.07.05 (2)
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.07.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.07.05
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.07.05 | Gebruiksfunctie | GO | Zuid, Oost | 78.3725 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: H
02.07.05 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.07.06 (8)
In: 07 zevende verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.07.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.07.06
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.07.06 | Woonkamer-keuken | A 279 | 04 | Verblijfsruimte | 26.6437 | 73.2703 | 73.2703 | MiniBIM ILS - Orientatie: Zuid, West
02.07.06 | Slaapkamer | A 280 | 03 | Verblijfsruimte | 9.37125 |  | 25.7709 | MiniBIM ILS - Orientatie: Zuid
02.07.06 | Slaapkamer | A 281 | 03 | Verblijfsruimte | 13.975 | 38.4313 | 38.4313 | MiniBIM ILS - Orientatie: West
02.07.06 | Entree | A 282 | 01 | Restruimte | 10.7332 | 29.5164 | 29.5164
02.07.06 | Bergruimte | A 283 | 06 | Restruimte | 2.0925 | 5.75437 | 5.75437
02.07.06 | Toiletruimte | A 284 | 07 | Restruimte | 1.1875 |  | 3.26563
02.07.06 | Badruimte | A 285 | 05 | Restruimte | 4.16 |  | 11.44
02.07.06 | Schacht | A 286 | 08 | Restruimte | 0.375 | 1.125 | 1.125

# IfcSpace: 02.07.06 (2)
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.07.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.07.06
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.07.06 | Gebruiksfunctie | GO | Zuid, West | 70.6182 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: G
02.07.06 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.08.01 (9)
In: 08 achtste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.01
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.08.01
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.08.01 | Slaapkamer | A 574 | 05 | Verblijfsruimte | 13.65 | 37.5375 | 37.5375 | MiniBIM ILS - Orientatie: West
02.08.01 | Slaapkamer | A 575 | 04 | Verblijfsruimte | 8.575 | 23.5813 | 23.5813 | MiniBIM ILS - Orientatie: West
02.08.01 | Woonkamer-keuken | A 576 | 02 | Verblijfsruimte | 31.9 | 87.725 | 87.725 | MiniBIM ILS - Orientatie: West
02.08.01 | Badruimte | A 577 | 06 | Restruimte | 4.16 |  | 11.44
02.08.01 | Toiletruimte | A 578 | 08 | Restruimte | 1.1875 |  | 3.26562
02.08.01 | Schacht | A 579 | 09 | Restruimte | 0.42 | 1.155 | 1.155
02.08.01 | Entree | A 580 | 01 | Restruimte | 4.62825 |  | 12.7277
02.08.01 | Gang | A 581 | 03 | Restruimte | 5.39 |  | 14.8225
02.08.01 | Bergruimte | A 582 | 07 | Restruimte | 4.83 | 13.2825 | 13.2825

# IfcSpace: 02.08.01 (2)
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.08.01; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.08.01
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.08.01 | Gebruiksfunctie | GO | 77.7495 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: F
02.08.01 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.08.02 (8)
In: 08 achtste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.08.02
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
02.08.02 | Woonkamer-keuken | A 813 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | MiniBIM ILS - Orientatie: Noord, West; Qto_SpaceBaseQuantities - GrossVolume: 85.1916 m3
02.08.02 | Slaapkamer | A 814 | 02 | Verblijfsruimte | 13.6525 | 37.5444 | MiniBIM ILS - Orientatie: Noord
02.08.02 | Slaapkamer | A 815 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | MiniBIM ILS - Orientatie: Noord
02.08.02 | Badruimte | A 816 | 05 | Restruimte | 5.5 | 15.125 | Qto_SpaceBaseQuantities - GrossVolume: 15.125 m3
02.08.02 | Toiletruimte | A 817 | 07 | Restruimte | 1.1875 | 3.26562
02.08.02 | Bergruimte | A 818 | 06 | Restruimte | 4.1527 | 11.4199
02.08.02 | Schacht | A 819 | 08 | Restruimte | 0.255 | 0.70125
02.08.02 | Entree | A 820 | 01 | Restruimte | 11.2207 | 30.8569

# IfcSpace: 02.08.02 (2)
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.08.02
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.08.02
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.08.02 | Gebruiksfunctie | GO | Noord, West | 77.3712 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: E
02.08.02 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.08.03 (9)
In: 08 achtste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.08.03
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.08.03 | Woonkamer-keuken | A 700 | 07 | Verblijfsruimte | 26.6437 | 73.2703 | 73.2703 | MiniBIM ILS - Orientatie: Noord, Oost
02.08.03 | Slaapkamer | A 701 | 06 | Verblijfsruimte | 13.975 | 38.4313 | 38.4313 | MiniBIM ILS - Orientatie: Oost
02.08.03 | Slaapkamer | A 702 | 08 | Verblijfsruimte | 9.9225 | 27.2869 | 27.2869 | MiniBIM ILS - Orientatie: Noord
02.08.03 | Bergruimte | A 703 | 09 | Restruimte | 4.06 |  | 11.165
02.08.03 | Badruimte | A 704 | 05 | Restruimte | 4.16 | 11.44 | 11.44
02.08.03 | Toiletruimte | A 705 | 03 | Restruimte | 1.1875 | 3.26563 | 3.26563
02.08.03 | Schacht | A 706 | 04 | Restruimte | 0.375 | 1.03125 | 1.03125
02.08.03 | Bergruimte | A 707 | 02 | Restruimte | 1.8225 | 5.01187 | 5.01187
02.08.03 | Entree | A 708 | 01 | Restruimte | 10.8075 | 29.7206 | 29.7206

# IfcSpace: 02.08.03 (2)
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.08.03
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.08.03
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.08.03 | Gebruiksfunctie | GO | Noord, Oost | 75.3187 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: J
02.08.03 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.08.04 (11)
In: 08 achtste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.04
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.08.04
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.08.04 | Woonkamer-keuken | A 446 | 02 | Verblijfsruimte | 31.9 | 87.725 | 87.725 | MiniBIM ILS - Orientatie: Oost
02.08.04 | Badruimte | A 447 | 05 | Restruimte | 4.16 | 11.44 | 11.44
02.08.04 | Slaapkamer | A 448 | 03 | Verblijfsruimte | 11.1475 | 30.6556 | 30.6556 | MiniBIM ILS - Orientatie: Oost
02.08.04 | Slaapkamer | A 449 | 04 | Verblijfsruimte | 13.65 | 37.5375 | 37.5375 | MiniBIM ILS - Orientatie: Oost
02.08.04 | Bergruimte | A 450 | 09 | Restruimte | 1.78875 | 4.91906 | 4.91906
02.08.04 | Toiletruimte | A 451 | 10 | Restruimte | 1.1875 | 3.26563 | 3.26563
02.08.04 | Schacht | A 452 | 11 | Restruimte | 0.34375 |  | 0.945313
02.08.04 | Entree | A 453 | 01 | Restruimte | 4.455 | 12.2513 | 12.2513
02.08.04 | Bergruimte | A 454 | 07 | Restruimte | 2.1 | 5.775 | 5.775
02.08.04 | Bergruimte | A 455 | 06 | Restruimte | 3.15 | 8.6625 | 8.6625
02.08.04 | Gang | A 456 | 08 | Restruimte | 4.235 |  | 11.6463

# IfcSpace: 02.08.04 (2)
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.08.04; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.08.04
Name | LongName | Bepalingsmethode | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.08.04 | Gebruiksfunctie | GO | 81.4275 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: I
02.08.04 | Area | NVO | 6.27 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.08.05 (8)
In: 08 achtste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.08.05
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | GrossVolume (m3) | NetVolume (m3)
02.08.05 | Woonkamer-keuken | A 183 | 04 | Verblijfsruimte | 30.9787 | 85.1916 | 85.1916 | MiniBIM ILS - Orientatie: Zuid, Oost
02.08.05 | Slaapkamer | A 184 | 03 | Verblijfsruimte | 7.9375 | 21.8281 | 21.8281 | MiniBIM ILS - Orientatie: Zuid
02.08.05 | Slaapkamer | A 185 | 02 | Verblijfsruimte | 14.1287 | 38.8541 | 38.8541 | MiniBIM ILS - Orientatie: Zuid
02.08.05 | Badruimte | A 186 | 05 | Restruimte | 5.5 | 15.125 | 15.125
02.08.05 | Bergruimte | A 187 | 06 | Restruimte | 4.5025 | 12.3819 | 12.3819
02.08.05 | Toiletruimte | A 188 | 07 | Restruimte | 1.1875 |  | 3.26563
02.08.05 | Schacht | A 189 | 08 | Restruimte | 0.255 |  | 0.70125
02.08.05 | Entree | A 190 | 01 | Restruimte | 11.365 |  | 31.2538

# IfcSpace: 02.08.05 (2)
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.08.05
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.08.05
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.08.05 | Gebruiksfunctie | GO | Zuid, Oost | 78.3725 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: H
02.08.05 | Area | NVO | Oost | 6.27 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Balkon

# IfcSpace: 02.08.06 (8)
In: 08 achtste verdieping
Pset_SpaceCommon - IsExternal: no
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; EenheidNummer: 02.08.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.08.06
Name | LongName = RuimteType | Pset_SpaceCommon, Reference = Pset_SpaceHeaterTypeCommon, Reference | RuimteNummer | RuimteSoort | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2) | NetVolume (m3)
02.08.06 | Woonkamer-keuken | A 295 | 04 | Verblijfsruimte | 26.6437 | 73.2703 | MiniBIM ILS - Orientatie: Zuid, West; Qto_SpaceBaseQuantities - GrossVolume: 73.2703 m3
02.08.06 | Slaapkamer | A 296 | 03 | Verblijfsruimte | 9.37125 | 25.7709 | MiniBIM ILS - Orientatie: Zuid
02.08.06 | Slaapkamer | A 297 | 03 | Verblijfsruimte | 13.975 | 38.4313 | MiniBIM ILS - Orientatie: West; Qto_SpaceBaseQuantities - GrossVolume: 38.4313 m3
02.08.06 | Entree | A 298 | 01 | Restruimte | 10.7332 | 29.5164 | Qto_SpaceBaseQuantities - GrossVolume: 29.5164 m3
02.08.06 | Bergruimte | A 299 | 06 | Restruimte | 2.0925 | 5.75437 | Qto_SpaceBaseQuantities - GrossVolume: 5.75437 m3
02.08.06 | Toiletruimte | A 300 | 07 | Restruimte | 1.1875 | 3.26563
02.08.06 | Badruimte | A 301 | 05 | Restruimte | 4.16 | 11.44
02.08.06 | Schacht | A 302 | 08 | Restruimte | 0.375 | 1.03125

# IfcSpace: 02.08.06 (2)
In: 08 achtste verdieping
Type - PredefinedType: USERDEFINED
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - BouwwerkNummer: 02; EenheidNummer: 02.08.06
Qto_SpaceBaseQuantities - Height: 3 m
Group: 02; 02.08.06
Name | LongName | Bepalingsmethode | Orientatie | GrossFloorArea (m2) = NetFloorArea (m2) = GrossCeilingArea (m2)
02.08.06 | Gebruiksfunctie | GO | Zuid, West | 70.6182 | MiniBIM ILS - Afnemer: Corporatie; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Programma: 3 kamer; Segment: VSH; WoningType: G
02.08.06 | Area | NVO | West | 6.27 | MiniBIM ILS - BuitenruimteSoort: Niet-overdekt; BuitenruimteType: Balkon

# IfcSpace: 71_PA_Parkeerplaats auto:openbaar 90° - 2400 (24)
Type - PredefinedType: USERDEFINED; Classification: 71.10 vaste verkeersvoorzieningen; standaard, algemeen (verzamelniveau) (NL-SfB); Material: markering
Pset_SpaceCommon - IsExternal: no; Reference: openbaar 90° - 2400
Pset_SpaceHeaterTypeCommon - Reference: openbaar 90° - 2400
MiniBIM ILS - Bepalingsmethode: NVO; BuitenruimteSoort: Subruimte; BuitenruimteType: Parkeerplaats auto
Qto_SpaceBaseQuantities - Height: 2.4 m; GrossFloorArea: 12.312 m2; GrossCeilingArea: 15.0515 m2; GrossVolume: 0.06156 m3; NetVolume: 0.06156 m3

# IfcSpace: 71_PA_Parkeerplaats auto:stalling 90° - 2400 (74)
Type - Classification: 71.10 vaste verkeersvoorzieningen; standaard, algemeen (verzamelniveau) (NL-SfB); Material: markering
Pset_SpaceCommon - IsExternal: no; Reference: stalling 90° - 2400
Pset_SpaceHeaterTypeCommon - Reference: stalling 90° - 2400
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 00; RuimteNummer: 01; RuimteSoort: Subruimte; RuimteType: Parkeerplaats auto
Qto_SpaceBaseQuantities - GrossFloorArea: 8.154 m2; GrossCeilingArea: 10.8875 m2; GrossVolume: 0.04077 m3; NetVolume: 0.04077 m3
Name | EenheidNummer | Height (m) | Group
Parkeerplaats auto | 01.07.03 | 4.53 | 01.07.03; 00
Parkeerplaats auto | 01.07.04 | 4.53 | 01.07.04; 00
Parkeerplaats auto | 01.07.05 | 4.53 | 01.07.05; 00
Parkeerplaats auto | 01.06.06 | 4.53 | 01.06.06; 00
Parkeerplaats auto | 01.07.01 | 4.53 | 01.07.01; 00
Parkeerplaats auto | 01.07.02 | 4.53 | 01.07.02; 00
Parkeerplaats auto | 01.07.06 | 4.53 | 01.07.06; 00
Parkeerplaats auto | 01.08.01 | 4.53 | 01.08.01; 00
Parkeerplaats auto | 01.08.02 | 4.53 | 01.08.02; 00
Parkeerplaats auto | 01.06.03 | 4.53 | 01.06.03; 00
Parkeerplaats auto | 01.06.04 | 4.53 | 01.06.04; 00
Parkeerplaats auto | 01.06.05 | 4.53 | 01.06.05; 00
Parkeerplaats auto | 01.08.03 | 4.53 | 01.08.03; 00
Parkeerplaats auto | 01.08.04 | 4.53 | 01.08.04; 00
Parkeerplaats auto | 01.08.05 | 4.53 | 01.08.05; 00
Parkeerplaats auto | 01.05.06 | 4.53 | 01.05.06; 00
Parkeerplaats auto | 01.06.01 | 4.53 | 01.06.01; 00
Parkeerplaats auto | 01.06.02 | 4.53 | 01.06.02; 00
Parkeerplaats auto | 01.08.06 | 4.53 | 01.08.06; 00
Parkeerplaats auto | 02.05.03 | 4.53 | 02.05.03; 00
Parkeerplaats auto | 02.05.04 | 4.53 | 02.05.04; 00
Parkeerplaats auto | 01.05.03 | 4.53 | 01.05.03; 00
Parkeerplaats auto | 01.05.04 | 4.53 | 01.05.04; 00
Parkeerplaats auto | 01.05.05 | 4.53 | 01.05.05; 00
Parkeerplaats auto | 02.05.05 | 4.53 | 02.05.05; 00
Parkeerplaats auto | 02.05.06 | 4.53 | 02.05.06; 00
Parkeerplaats auto | 01.05.01 | 4.53 | 01.05.01; 00
Parkeerplaats auto | 01.05.02 | 4.53 | 01.05.02; 00
Parkeerplaats auto | 02.08.06 | 1.8 | 02.08.06; 00
Parkeerplaats auto | 02.08.05 | 1.8 | 02.08.05; 00
Parkeerplaats auto | 02.08.04 | 1.8 | 02.08.04; 00
Parkeerplaats auto | 01.00.03 | 1.8 | 01.00.03; 00
Parkeerplaats auto | 01.00.02 | 1.8 | 01.00.02; 00
Parkeerplaats auto | 01.00.01 | 1.8 | 01.00.01; 00
Parkeerplaats auto | 02.08.03 | 1.8 | 02.08.03; 00
Parkeerplaats auto | 02.08.02 | 1.8 | 02.08.02; 00
Parkeerplaats auto | 02.08.01 | 1.8 | 02.08.01; 00
Parkeerplaats auto | 01.00.06 | 1.8 | 01.00.06; 00
Parkeerplaats auto | 01.00.05 | 1.8 | 01.00.05; 00
Parkeerplaats auto | 01.00.04 | 1.8 | 01.00.04; 00
Parkeerplaats auto | 02.07.06 | 1.8 | 02.07.06; 00
Parkeerplaats auto | 02.07.05 | 1.8 | 02.07.05; 00
Parkeerplaats auto | 02.07.04 | 1.8 | 02.07.04; 00
Parkeerplaats auto | 01.01.03 | 1.8 | 01.01.03; 00
Parkeerplaats auto | 01.01.02 | 1.8 | 01.01.02; 00
Parkeerplaats auto | 01.01.01 | 1.8 | 01.01.01; 00
Parkeerplaats auto | 02.07.03 | 1.8 | 02.07.03; 00
Parkeerplaats auto | 02.07.02 | 1.8 | 02.07.02; 00
Parkeerplaats auto | 02.07.01 | 1.8 | 02.07.01; 00
Parkeerplaats auto | 01.02.02 | 1.8 | 01.02.02; 00
Parkeerplaats auto | 01.02.01 | 1.8 | 01.02.01; 00
Parkeerplaats auto | 01.01.04 | 1.8 | 01.01.04; 00
Parkeerplaats auto | 02.06.06 | 1.8 | 02.06.06; 00
Parkeerplaats auto | 02.06.05 | 1.8 | 02.06.05; 00
Parkeerplaats auto | 01.02.04 | 1.8 | 01.02.04; 00
Parkeerplaats auto | 01.02.03 | 1.8 | 01.02.03; 00
Parkeerplaats auto | 01.04.06 | 4.53 | 01.04.06; 00
Parkeerplaats auto | 01.04.04 | 4.53 | 01.04.04; 00
Parkeerplaats auto | 01.04.05 | 4.53 | 01.04.05; 00
Parkeerplaats auto | 01.04.03 | 4.53 | 01.04.03; 00
Parkeerplaats auto | 01.04.01 | 4.53 | 01.04.01; 00
Parkeerplaats auto | 01.04.02 | 4.53 | 01.04.02; 00
Parkeerplaats auto | 01.03.06 | 4.53 | 01.03.06; 00
Parkeerplaats auto | 01.02.05 | 1.8 | 01.02.05; 00
Parkeerplaats auto | 01.03.01 | 1.8 | 01.03.01; 00
Parkeerplaats auto | 01.02.06 | 1.8 | 01.02.06; 00
Parkeerplaats auto | 01.03.02 | 1.8 | 01.03.02; 00
Parkeerplaats auto | 01.03.04 | 1.8 | 01.03.04; 00
Parkeerplaats auto | 01.03.03 | 1.8 | 01.03.03; 00
Parkeerplaats auto | 01.03.05 | 1.8 | 01.03.05; 00
Parkeerplaats auto | 02.06.02 | 4.53 | 02.06.02; 00
Parkeerplaats auto | 02.06.03 | 1.8 | 02.06.03; 00
Parkeerplaats auto | 02.06.01 | 4.53 | 02.06.01; 00
Parkeerplaats auto | 02.06.04 | 1.8 | 02.06.04; 00

# IfcSpace: 71_PA_Parkeerplaats bakfiets:Parkeerplaats bakfiets (28)
Type - PredefinedType: USERDEFINED; Classification: 71.10 vaste verkeersvoorzieningen; standaard, algemeen (verzamelniveau) (NL-SfB); Material: parkeervak
Pset_SpaceCommon - IsExternal: no; Reference: Parkeerplaats bakfiets
Pset_SpaceHeaterTypeCommon - Reference: Parkeerplaats bakfiets
MiniBIM ILS - Bepalingsmethode: NVO; RuimteNummer: 03; RuimteSoort: Subruimte; RuimteType: Parkeerplaats bakfiets
Qto_SpaceBaseQuantities - GrossFloorArea: 1.915 m2; GrossCeilingArea: 1.92958 m2; GrossVolume: 0.009575 m3; NetVolume: 0.009575 m3
Name | BouwwerkNummer = Group | Height (m)
14 x Parkeerplaats bakfiets | 01 | 1.915
14 x Parkeerplaats bakfiets | 02 | 1

# IfcSpace: 71_PA_Parkeerplaats fiets:Parkeerplaats fiets hoog (208)
Type - PredefinedType: USERDEFINED; Classification: 71.10 vaste verkeersvoorzieningen; standaard, algemeen (verzamelniveau) (NL-SfB); Material: markering
Pset_SpaceCommon - IsExternal: no; Reference: Parkeerplaats fiets hoog
Pset_SpaceHeaterTypeCommon - Reference: Parkeerplaats fiets hoog
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 00; RuimteSoort: Subruimte; RuimteType: Parkeerplaats fiets hoog
Qto_SpaceBaseQuantities - GrossFloorArea: 0.766 m2; GrossCeilingArea: 0.777575 m2; GrossVolume: 0.00383 m3; NetVolume: 0.00383 m3
Name | EenheidNummer | RuimteNummer | Height (m) | Group
2 x Parkeerplaats fiets hoog | 02.01.02 | 01 | 1.915 | 02.01.02; 00
2 x Parkeerplaats fiets hoog | 02.02.05 | 01 | 1.915 | 02.02.05; 00
2 x Parkeerplaats fiets hoog | 02.02.06 | 01 | 1.915 | 02.02.06; 00
2 x Parkeerplaats fiets hoog | 02.01.03 | 01 | 1.915 | 02.01.03; 00
2 x Parkeerplaats fiets hoog | 02.01.04 | 01 | 1.915 | 02.01.04; 00
2 x Parkeerplaats fiets hoog | 02.02.01 | 01 | 1.915 | 02.02.01; 00
2 x Parkeerplaats fiets hoog | 02.02.02 | 01 | 1.915 | 02.02.02; 00
2 x Parkeerplaats fiets hoog | 02.02.03 | 01 | 1.915 | 02.02.03; 00
