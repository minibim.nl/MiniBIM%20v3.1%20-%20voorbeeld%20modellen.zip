Properties of the parts of a building model (IFC4), part 5 of 12

# IfcSpace: 71_PA_Parkeerplaats fiets:Parkeerplaats fiets hoog (208)
Name | EenheidNummer | RuimteNummer | Height (m) | Group
2 x Parkeerplaats fiets hoog | 02.02.04 | 01 | 1.915 | 02.02.04; 00
2 x Parkeerplaats fiets hoog | 02.07.03 | 01 | 0.4 | 02.07.03; 00
2 x Parkeerplaats fiets hoog | 02.06.02 | 01 | 0.4 | 02.06.02; 00
2 x Parkeerplaats fiets hoog | 02.06.01 | 01 | 0.4 | 02.06.01; 00
2 x Parkeerplaats fiets hoog | 02.07.02 | 01 | 0.4 | 02.07.02; 00
2 x Parkeerplaats fiets hoog | 02.07.01 | 01 | 0.4 | 02.07.01; 00
2 x Parkeerplaats fiets hoog | 02.06.06 | 01 | 0.4 | 02.06.06; 00
2 x Parkeerplaats fiets hoog | 02.06.05 | 01 | 0.4 | 02.06.05; 00
2 x Parkeerplaats fiets hoog | 02.06.04 | 01 | 0.4 | 02.06.04; 00
2 x Parkeerplaats fiets hoog | 02.06.03 | 01 | 0.4 | 02.06.03; 00
2 x Parkeerplaats fiets hoog | 02.00.01 | 01 | 1.915 | 02.00.01; 00
6 x Parkeerplaats fiets hoog | 02.00.04 | 01 | 1.915 | 00; 02.00.04
2 x Parkeerplaats fiets hoog | 02.01.01 | 01 | 1.915 | 02.01.01; 00
2 x Parkeerplaats fiets hoog | 02.00.02 | 01 | 1.915 | 02.00.02; 00
2 x Parkeerplaats fiets hoog | 02.00.03 | 01 | 1.915 | 02.00.03; 00
2 x Parkeerplaats fiets hoog | 02.08.06 | 01 | 0.4 | 02.08.06; 00
2 x Parkeerplaats fiets hoog | 02.07.05 | 01 | 0.4 | 02.07.05; 00
2 x Parkeerplaats fiets hoog | 02.07.04 | 01 | 0.4 | 02.07.04; 00
2 x Parkeerplaats fiets hoog | 02.08.04 | 01 | 0.4 | 02.08.04; 00
2 x Parkeerplaats fiets hoog | 02.08.03 | 01 | 0.4 | 02.08.03; 00
2 x Parkeerplaats fiets hoog | 02.08.02 | 01 | 0.4 | 02.08.02; 00
2 x Parkeerplaats fiets hoog | 02.08.01 | 01 | 0.4 | 02.08.01; 00
2 x Parkeerplaats fiets hoog | 02.07.06 | 01 | 0.4 | 02.07.06; 00
2 x Parkeerplaats fiets hoog | 02.03.01 | 01 | 1.915 | 02.03.01; 00
2 x Parkeerplaats fiets hoog | 02.04.02 | 01 | 1.915 | 02.04.02; 00
2 x Parkeerplaats fiets hoog | 02.04.03 | 01 | 1.915 | 02.04.03; 00
2 x Parkeerplaats fiets hoog | 02.04.01 | 01 | 1.915 | 02.04.01; 00
2 x Parkeerplaats fiets hoog | 02.05.06 | 01 | 0.4 | 02.05.06; 00
2 x Parkeerplaats fiets hoog | 02.04.05 | 01 | 0.4 | 02.04.05; 00
2 x Parkeerplaats fiets hoog | 02.04.04 | 01 | 0.4 | 02.04.04; 00
2 x Parkeerplaats fiets hoog | 02.05.05 | 01 | 0.4 | 02.05.05; 00
2 x Parkeerplaats fiets hoog | 02.05.04 | 01 | 0.4 | 02.05.04; 00
2 x Parkeerplaats fiets hoog | 02.05.03 | 01 | 0.4 | 02.05.03; 00
2 x Parkeerplaats fiets hoog | 02.05.02 | 01 | 0.4 | 02.05.02; 00
2 x Parkeerplaats fiets hoog | 02.05.01 | 01 | 0.4 | 02.05.01; 00
2 x Parkeerplaats fiets hoog | 02.04.06 | 01 | 0.4 | 02.04.06; 00
2 x Parkeerplaats fiets hoog | 02.03.04 | 01 | 1.915 | 02.03.04; 00
2 x Parkeerplaats fiets hoog | 02.03.05 | 01 | 1.915 | 02.03.05; 00
2 x Parkeerplaats fiets hoog | 02.03.06 | 01 | 1.915 | 02.03.06; 00
2 x Parkeerplaats fiets hoog | 02.03.02 | 01 | 1.915 | 02.03.02; 00
2 x Parkeerplaats fiets hoog | 02.03.03 | 01 | 1.915 | 02.03.03; 00
2 x Parkeerplaats fiets hoog | 02.08.05 | 01 | 0.4 | 02.08.05; 00
2 x Parkeerplaats fiets hoog | 01.01.04 | 22 | 1.915 | 01.01.04; 00
2 x Parkeerplaats fiets hoog | 01.03.01 | 22 | 1.915 | 01.03.01; 00
2 x Parkeerplaats fiets hoog | 01.03.02 | 22 | 1.915 | 01.03.02; 00
2 x Parkeerplaats fiets hoog | 01.02.01 | 22 | 1.915 | 01.02.01; 00
2 x Parkeerplaats fiets hoog | 01.02.02 | 22 | 1.915 | 01.02.02; 00
2 x Parkeerplaats fiets hoog | 01.02.03 | 22 | 1.915 | 01.02.03; 00
2 x Parkeerplaats fiets hoog | 01.02.04 | 22 | 1.915 | 01.02.04; 00
2 x Parkeerplaats fiets hoog | 01.02.05 | 22 | 1.915 | 01.02.05; 00
2 x Parkeerplaats fiets hoog | 01.02.06 | 22 | 1.915 | 01.02.06; 00
2 x Parkeerplaats fiets hoog | 01.00.01 | 22 | 1.915 | 01.00.01; 00
2 x Parkeerplaats fiets hoog | 01.01.02 | 22 | 1.915 | 01.01.02; 00
2 x Parkeerplaats fiets hoog | 01.01.03 | 22 | 1.915 | 01.01.03; 00
2 x Parkeerplaats fiets hoog | 01.00.03 | 22 | 1.915 | 01.00.03; 00
2 x Parkeerplaats fiets hoog | 01.00.04 | 22 | 1.915 | 01.00.04; 00
2 x Parkeerplaats fiets hoog | 01.00.05 | 22 | 1.915 | 01.00.05; 00
2 x Parkeerplaats fiets hoog | 01.00.06 | 22 | 1.915 | 01.00.06; 00
2 x Parkeerplaats fiets hoog | 01.01.01 | 22 | 1.915 | 01.01.01; 00
2 x Parkeerplaats fiets hoog | 01.08.06 | 22 | 0.4 | 01.08.06; 00
2 x Parkeerplaats fiets hoog | 01.08.01 | 22 | 0.4 | 01.08.01; 00
2 x Parkeerplaats fiets hoog | 01.07.06 | 22 | 0.4 | 01.07.06; 00
2 x Parkeerplaats fiets hoog | 01.08.05 | 22 | 0.4 | 01.08.05; 00
2 x Parkeerplaats fiets hoog | 01.08.04 | 22 | 0.4 | 01.08.04; 00
2 x Parkeerplaats fiets hoog | 01.08.03 | 22 | 0.4 | 01.08.03; 00
2 x Parkeerplaats fiets hoog | 01.08.02 | 22 | 0.4 | 01.08.02; 00
2 x Parkeerplaats fiets hoog | 01.06.02 | 22 | 0.4 | 01.06.02; 00
2 x Parkeerplaats fiets hoog | 01.05.01 | 22 | 0.4 | 01.05.01; 00
2 x Parkeerplaats fiets hoog | 01.04.06 | 22 | 0.4 | 01.04.06; 00
2 x Parkeerplaats fiets hoog | 01.05.02 | 22 | 0.4 | 01.05.02; 00
2 x Parkeerplaats fiets hoog | 01.03.03 | 22 | 1.915 | 01.03.03; 00
2 x Parkeerplaats fiets hoog | 01.04.04 | 22 | 1.915 | 01.04.04; 00
2 x Parkeerplaats fiets hoog | 01.04.05 | 22 | 1.915 | 01.04.05; 00
2 x Parkeerplaats fiets hoog | 01.03.04 | 22 | 1.915 | 01.03.04; 00
2 x Parkeerplaats fiets hoog | 01.03.05 | 22 | 1.915 | 01.03.05; 00
2 x Parkeerplaats fiets hoog | 01.03.06 | 22 | 1.915 | 01.03.06; 00
2 x Parkeerplaats fiets hoog | 01.04.01 | 22 | 1.915 | 01.04.01; 00
2 x Parkeerplaats fiets hoog | 01.04.02 | 22 | 1.915 | 01.04.02; 00
2 x Parkeerplaats fiets hoog | 01.04.03 | 22 | 1.915 | 01.04.03; 00
2 x Parkeerplaats fiets hoog | 01.05.05 | 22 | 0.4 | 01.05.05; 00
2 x Parkeerplaats fiets hoog | 01.05.04 | 22 | 0.4 | 01.05.04; 00
2 x Parkeerplaats fiets hoog | 01.05.03 | 22 | 0.4 | 01.05.03; 00
2 x Parkeerplaats fiets hoog | 01.06.01 | 22 | 0.4 | 01.06.01; 00
2 x Parkeerplaats fiets hoog | 01.05.06 | 22 | 0.4 | 01.05.06; 00
2 x Parkeerplaats fiets hoog | 01.07.05 | 22 | 0.4 | 01.07.05; 00
2 x Parkeerplaats fiets hoog | 01.06.04 | 22 | 0.4 | 01.06.04; 00
2 x Parkeerplaats fiets hoog | 01.06.03 | 22 | 0.4 | 01.06.03; 00
2 x Parkeerplaats fiets hoog | 01.06.05 | 22 | 0.4 | 01.06.05; 00
2 x Parkeerplaats fiets hoog | 01.07.02 | 22 | 0.4 | 01.07.02; 00
2 x Parkeerplaats fiets hoog | 01.07.01 | 22 | 0.4 | 01.07.01; 00
2 x Parkeerplaats fiets hoog | 01.06.06 | 22 | 0.4 | 01.06.06; 00
2 x Parkeerplaats fiets hoog | 01.07.04 | 22 | 0.4 | 01.07.04; 00
2 x Parkeerplaats fiets hoog | 01.07.03 | 22 | 0.4 | 01.07.03; 00
2 x Parkeerplaats fiets hoog | 01.00.02 | 22 | 1.915 | 01.00.02; 00

# IfcSpace: 71_PA_Parkeerplaats fiets:Parkeerplaats fiets laag (208)
Type - PredefinedType: USERDEFINED; Classification: 71.10 vaste verkeersvoorzieningen; standaard, algemeen (verzamelniveau) (NL-SfB); Material: markering
Pset_SpaceCommon - IsExternal: no; Reference: Parkeerplaats fiets laag
Pset_SpaceHeaterTypeCommon - Reference: Parkeerplaats fiets laag
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 00; RuimteSoort: Subruimte; RuimteType: Parkeerplaats fiets laag
Qto_SpaceBaseQuantities - GrossFloorArea: 0.766 m2; GrossCeilingArea: 0.777575 m2; GrossVolume: 0.00383 m3; NetVolume: 0.00383 m3
Name | EenheidNummer | RuimteNummer | Height (m) | Group
2 x Parkeerplaats fiets laag | 02.01.02 | 01 | 1.915 | 02.01.02; 00
2 x Parkeerplaats fiets laag | 02.02.05 | 01 | 1.915 | 02.02.05; 00
2 x Parkeerplaats fiets laag | 02.02.06 | 01 | 1.915 | 02.02.06; 00
2 x Parkeerplaats fiets laag | 02.01.03 | 01 | 1.915 | 02.01.03; 00
2 x Parkeerplaats fiets laag | 02.01.04 | 01 | 1.915 | 02.01.04; 00
2 x Parkeerplaats fiets laag | 02.02.01 | 01 | 1.915 | 02.02.01; 00
2 x Parkeerplaats fiets laag | 02.02.02 | 01 | 1.915 | 02.02.02; 00
2 x Parkeerplaats fiets laag | 02.02.03 | 01 | 1.915 | 02.02.03; 00
2 x Parkeerplaats fiets laag | 02.02.04 | 01 | 1.915 | 02.02.04; 00
2 x Parkeerplaats fiets laag | 02.07.03 | 01 | 0.4 | 02.07.03; 00
2 x Parkeerplaats fiets laag | 02.06.02 | 01 | 0.4 | 02.06.02; 00
2 x Parkeerplaats fiets laag | 02.06.01 | 01 | 0.4 | 02.06.01; 00
2 x Parkeerplaats fiets laag | 02.07.02 | 01 | 0.4 | 02.07.02; 00
2 x Parkeerplaats fiets laag | 02.07.01 | 01 | 0.4 | 02.07.01; 00
2 x Parkeerplaats fiets laag | 02.06.06 | 01 | 0.4 | 02.06.06; 00
2 x Parkeerplaats fiets laag | 02.06.05 | 01 | 0.4 | 02.06.05; 00
2 x Parkeerplaats fiets laag | 02.06.04 | 01 | 0.4 | 02.06.04; 00
2 x Parkeerplaats fiets laag | 02.06.03 | 01 | 0.4 | 02.06.03; 00
2 x Parkeerplaats fiets laag | 02.00.01 | 01 | 1.915 | 02.00.01; 00
6 x Parkeerplaats fiets laag | 02.00.04 | 01 | 1.915 | 00; 02.00.04
2 x Parkeerplaats fiets laag | 02.01.01 | 01 | 1.915 | 02.01.01; 00
2 x Parkeerplaats fiets laag | 02.00.02 | 01 | 1.915 | 02.00.02; 00
2 x Parkeerplaats fiets laag | 02.00.03 | 01 | 1.915 | 02.00.03; 00
2 x Parkeerplaats fiets laag | 02.08.06 | 01 | 0.4 | 02.08.06; 00
2 x Parkeerplaats fiets laag | 02.07.05 | 01 | 0.4 | 02.07.05; 00
2 x Parkeerplaats fiets laag | 02.07.04 | 01 | 0.4 | 02.07.04; 00
2 x Parkeerplaats fiets laag | 02.08.04 | 01 | 0.4 | 02.08.04; 00
2 x Parkeerplaats fiets laag | 02.08.03 | 01 | 0.4 | 02.08.03; 00
2 x Parkeerplaats fiets laag | 02.08.02 | 01 | 0.4 | 02.08.02; 00
2 x Parkeerplaats fiets laag | 02.08.01 | 01 | 0.4 | 02.08.01; 00
2 x Parkeerplaats fiets laag | 02.07.06 | 01 | 0.4 | 02.07.06; 00
2 x Parkeerplaats fiets laag | 02.03.01 | 01 | 1.915 | 02.03.01; 00
2 x Parkeerplaats fiets laag | 02.04.02 | 01 | 1.915 | 02.04.02; 00
2 x Parkeerplaats fiets laag | 02.04.03 | 01 | 1.915 | 02.04.03; 00
2 x Parkeerplaats fiets laag | 02.04.01 | 01 | 1.915 | 02.04.01; 00
2 x Parkeerplaats fiets laag | 02.05.06 | 01 | 0.4 | 02.05.06; 00
2 x Parkeerplaats fiets laag | 02.04.05 | 01 | 0.4 | 02.04.05; 00
2 x Parkeerplaats fiets laag | 02.04.04 | 01 | 0.4 | 02.04.04; 00
2 x Parkeerplaats fiets laag | 02.05.05 | 01 | 0.4 | 02.05.05; 00
2 x Parkeerplaats fiets laag | 02.05.04 | 01 | 0.4 | 02.05.04; 00
2 x Parkeerplaats fiets laag | 02.05.03 | 01 | 0.4 | 02.05.03; 00
2 x Parkeerplaats fiets laag | 02.05.02 | 01 | 0.4 | 02.05.02; 00
2 x Parkeerplaats fiets laag | 02.05.01 | 01 | 0.4 | 02.05.01; 00
2 x Parkeerplaats fiets laag | 02.04.06 | 01 | 0.4 | 02.04.06; 00
2 x Parkeerplaats fiets laag | 02.03.04 | 01 | 1.915 | 02.03.04; 00
2 x Parkeerplaats fiets laag | 02.03.05 | 01 | 1.915 | 02.03.05; 00
2 x Parkeerplaats fiets laag | 02.03.06 | 01 | 1.915 | 02.03.06; 00
2 x Parkeerplaats fiets laag | 02.03.02 | 01 | 1.915 | 02.03.02; 00
2 x Parkeerplaats fiets laag | 02.03.03 | 01 | 1.915 | 02.03.03; 00
2 x Parkeerplaats fiets laag | 02.08.05 | 01 | 0.4 | 02.08.05; 00
2 x Parkeerplaats fiets laag | 01.01.04 | 22 | 1.915 | 01.01.04; 00
2 x Parkeerplaats fiets laag | 01.03.01 | 22 | 1.915 | 01.03.01; 00
2 x Parkeerplaats fiets laag | 01.03.02 | 22 | 1.915 | 01.03.02; 00
2 x Parkeerplaats fiets laag | 01.02.01 | 22 | 1.915 | 01.02.01; 00
2 x Parkeerplaats fiets laag | 01.02.02 | 22 | 1.915 | 01.02.02; 00
2 x Parkeerplaats fiets laag | 01.02.03 | 22 | 1.915 | 01.02.03; 00
2 x Parkeerplaats fiets laag | 01.02.04 | 22 | 1.915 | 01.02.04; 00
2 x Parkeerplaats fiets laag | 01.02.05 | 22 | 1.915 | 01.02.05; 00
2 x Parkeerplaats fiets laag | 01.02.06 | 22 | 1.915 | 01.02.06; 00
2 x Parkeerplaats fiets laag | 01.00.01 | 22 | 1.915 | 01.00.01; 00
2 x Parkeerplaats fiets laag | 01.01.02 | 22 | 1.915 | 01.01.02; 00
2 x Parkeerplaats fiets laag | 01.01.03 | 22 | 1.915 | 01.01.03; 00
2 x Parkeerplaats fiets laag | 01.00.03 | 22 | 1.915 | 01.00.03; 00
2 x Parkeerplaats fiets laag | 01.00.04 | 22 | 1.915 | 01.00.04; 00
2 x Parkeerplaats fiets laag | 01.00.05 | 22 | 1.915 | 01.00.05; 00
2 x Parkeerplaats fiets laag | 01.00.06 | 22 | 1.915 | 01.00.06; 00
2 x Parkeerplaats fiets laag | 01.01.01 | 22 | 1.915 | 01.01.01; 00
2 x Parkeerplaats fiets laag | 01.08.06 | 22 | 0.4 | 01.08.06; 00
2 x Parkeerplaats fiets laag | 01.08.01 | 22 | 0.4 | 01.08.01; 00
2 x Parkeerplaats fiets laag | 01.07.06 | 22 | 0.4 | 01.07.06; 00
2 x Parkeerplaats fiets laag | 01.08.05 | 22 | 0.4 | 01.08.05; 00
2 x Parkeerplaats fiets laag | 01.08.04 | 22 | 0.4 | 01.08.04; 00
2 x Parkeerplaats fiets laag | 01.08.03 | 22 | 0.4 | 01.08.03; 00
2 x Parkeerplaats fiets laag | 01.08.02 | 22 | 0.4 | 01.08.02; 00
2 x Parkeerplaats fiets laag | 01.06.02 | 22 | 0.4 | 01.06.02; 00
2 x Parkeerplaats fiets laag | 01.05.01 | 22 | 0.4 | 01.05.01; 00
2 x Parkeerplaats fiets laag | 01.04.06 | 22 | 0.4 | 01.04.06; 00
2 x Parkeerplaats fiets laag | 01.05.02 | 22 | 0.4 | 01.05.02; 00
2 x Parkeerplaats fiets laag | 01.03.03 | 22 | 1.915 | 01.03.03; 00
2 x Parkeerplaats fiets laag | 01.04.04 | 22 | 1.915 | 01.04.04; 00
2 x Parkeerplaats fiets laag | 01.04.05 | 22 | 1.915 | 01.04.05; 00
2 x Parkeerplaats fiets laag | 01.03.04 | 22 | 1.915 | 01.03.04; 00
2 x Parkeerplaats fiets laag | 01.03.05 | 22 | 1.915 | 01.03.05; 00
2 x Parkeerplaats fiets laag | 01.03.06 | 22 | 1.915 | 01.03.06; 00
2 x Parkeerplaats fiets laag | 01.04.01 | 22 | 1.915 | 01.04.01; 00
2 x Parkeerplaats fiets laag | 01.04.02 | 22 | 1.915 | 01.04.02; 00
2 x Parkeerplaats fiets laag | 01.04.03 | 22 | 1.915 | 01.04.03; 00
2 x Parkeerplaats fiets laag | 01.05.05 | 22 | 0.4 | 01.05.05; 00
2 x Parkeerplaats fiets laag | 01.05.04 | 22 | 0.4 | 01.05.04; 00
2 x Parkeerplaats fiets laag | 01.05.03 | 22 | 0.4 | 01.05.03; 00
2 x Parkeerplaats fiets laag | 01.06.01 | 22 | 0.4 | 01.06.01; 00
2 x Parkeerplaats fiets laag | 01.05.06 | 22 | 0.4 | 01.05.06; 00
2 x Parkeerplaats fiets laag | 01.07.05 | 22 | 0.4 | 01.07.05; 00
2 x Parkeerplaats fiets laag | 01.06.04 | 22 | 0.4 | 01.06.04; 00
2 x Parkeerplaats fiets laag | 01.06.03 | 22 | 0.4 | 01.06.03; 00
2 x Parkeerplaats fiets laag | 01.06.05 | 22 | 0.4 | 01.06.05; 00
2 x Parkeerplaats fiets laag | 01.07.02 | 22 | 0.4 | 01.07.02; 00
2 x Parkeerplaats fiets laag | 01.07.01 | 22 | 0.4 | 01.07.01; 00
2 x Parkeerplaats fiets laag | 01.06.06 | 22 | 0.4 | 01.06.06; 00
2 x Parkeerplaats fiets laag | 01.07.04 | 22 | 0.4 | 01.07.04; 00
2 x Parkeerplaats fiets laag | 01.07.03 | 22 | 0.4 | 01.07.03; 00
2 x Parkeerplaats fiets laag | 01.00.02 | 22 | 1.915 | 01.00.02; 00

# IfcSpace: 71_PA_Parkeerplaats scooter:Parkeerplaats scooter (18)
Type - PredefinedType: USERDEFINED; Classification: 71.10 vaste verkeersvoorzieningen; standaard, algemeen (verzamelniveau) (NL-SfB); Material: parkeervak
Pset_SpaceCommon - IsExternal: no; Reference: Parkeerplaats scooter
Pset_SpaceHeaterTypeCommon - Reference: Parkeerplaats scooter
MiniBIM ILS - Bepalingsmethode: NVO; RuimteNummer: 03; RuimteSoort: Subruimte; RuimteType: Parkeerplaats scooter
Qto_SpaceBaseQuantities - GrossFloorArea: 1.43625 m2; GrossCeilingArea: 1.44958 m2; GrossVolume: 0.00718125 m3; NetVolume: 0.00718125 m3
Name | BouwwerkNummer = Group | Height (m)
9 x Parkeerplaats scooter | 01 | 1.915
9 x Parkeerplaats scooter | 02 | 0.75

# IfcSpace: A 1066:1671360, 1066
In: 02 tweede verdieping
LongName: Lifthal; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1066
Pset_SpaceHeaterTypeCommon - Reference: A 1066
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; NetVolume: 28.2562 m3

# IfcSpace: A 1067:1671380, 1067
In: 02 tweede verdieping
LongName: Trappenhuis; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1067
Pset_SpaceHeaterTypeCommon - Reference: A 1067
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 43.032 m3

# IfcSpace: A 1068:1671397, 1068
In: 02 tweede verdieping
LongName: Liftschacht; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1068
Pset_SpaceHeaterTypeCommon - Reference: A 1068
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1069:1671410, 1069
In: 02 tweede verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1069
Pset_SpaceHeaterTypeCommon - Reference: A 1069
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1070:1671419, 1070
In: 02 tweede verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1070
Pset_SpaceHeaterTypeCommon - Reference: A 1070
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1076:1671856, 1076
In: 03 derde verdieping
LongName: Lifthal; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1076
Pset_SpaceHeaterTypeCommon - Reference: A 1076
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; NetVolume: 28.2562 m3

# IfcSpace: A 1077:1671857, 1077
In: 03 derde verdieping
LongName: Trappenhuis; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1077
Pset_SpaceHeaterTypeCommon - Reference: A 1077
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 43.032 m3

# IfcSpace: A 1078:1671858, 1078
In: 03 derde verdieping
LongName: Liftschacht; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1078
Pset_SpaceHeaterTypeCommon - Reference: A 1078
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1079:1671859, 1079
In: 03 derde verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1079
Pset_SpaceHeaterTypeCommon - Reference: A 1079
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1080:1671860, 1080
In: 03 derde verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1080
Pset_SpaceHeaterTypeCommon - Reference: A 1080
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1081:1671863, 1081
In: 04 vierde verdieping
LongName: Lifthal; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1081
Pset_SpaceHeaterTypeCommon - Reference: A 1081
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; NetVolume: 28.2562 m3

# IfcSpace: A 1082:1671864, 1082
In: 04 vierde verdieping
LongName: Trappenhuis; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1082
Pset_SpaceHeaterTypeCommon - Reference: A 1082
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 43.032 m3

# IfcSpace: A 1083:1671865, 1083
In: 04 vierde verdieping
LongName: Liftschacht; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1083
Pset_SpaceHeaterTypeCommon - Reference: A 1083
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1084:1671866, 1084
In: 04 vierde verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1084
Pset_SpaceHeaterTypeCommon - Reference: A 1084
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1085:1671867, 1085
In: 04 vierde verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1085
Pset_SpaceHeaterTypeCommon - Reference: A 1085
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1086:1671870, 1086
In: 05 vijfde verdieping
LongName: Lifthal; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1086
Pset_SpaceHeaterTypeCommon - Reference: A 1086
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; NetVolume: 28.2562 m3

# IfcSpace: A 1087:1671871, 1087
In: 05 vijfde verdieping
LongName: Trappenhuis; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1087
Pset_SpaceHeaterTypeCommon - Reference: A 1087
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 43.032 m3

# IfcSpace: A 1088:1671872, 1088
In: 05 vijfde verdieping
LongName: Liftschacht; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1088
Pset_SpaceHeaterTypeCommon - Reference: A 1088
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1089:1671873, 1089
In: 05 vijfde verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1089
Pset_SpaceHeaterTypeCommon - Reference: A 1089
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1090:1671874, 1090
In: 05 vijfde verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1090
Pset_SpaceHeaterTypeCommon - Reference: A 1090
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1091:1671877, 1091
In: 06 zesde verdieping
LongName: Lifthal; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1091
Pset_SpaceHeaterTypeCommon - Reference: A 1091
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; NetVolume: 28.2562 m3

# IfcSpace: A 1092:1671878, 1092
In: 06 zesde verdieping
LongName: Trappenhuis; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1092
Pset_SpaceHeaterTypeCommon - Reference: A 1092
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 43.032 m3

# IfcSpace: A 1093:1671879, 1093
In: 06 zesde verdieping
LongName: Liftschacht; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1093
Pset_SpaceHeaterTypeCommon - Reference: A 1093
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1094:1671880, 1094
In: 06 zesde verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1094
Pset_SpaceHeaterTypeCommon - Reference: A 1094
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1095:1671881, 1095
In: 06 zesde verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1095
Pset_SpaceHeaterTypeCommon - Reference: A 1095
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1096:1671884, 1096
In: 02 tweede verdieping
LongName: Lifthal; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1096
Pset_SpaceHeaterTypeCommon - Reference: A 1096
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; GrossVolume: 28.2562 m3; NetVolume: 28.2562 m3

# IfcSpace: A 1097:1671885, 1097
In: 02 tweede verdieping
LongName: Trappenhuis; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1097
Pset_SpaceHeaterTypeCommon - Reference: A 1097
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 43.032 m3

# IfcSpace: A 1098:1671886, 1098
In: 02 tweede verdieping
LongName: Liftschacht; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1098
Pset_SpaceHeaterTypeCommon - Reference: A 1098
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1099:1671887, 1099
In: 02 tweede verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1099
Pset_SpaceHeaterTypeCommon - Reference: A 1099
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1100:1671888, 1100
In: 02 tweede verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1100
Pset_SpaceHeaterTypeCommon - Reference: A 1100
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1101:1671891, 1101
In: 03 derde verdieping
LongName: Lifthal; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1101
Pset_SpaceHeaterTypeCommon - Reference: A 1101
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; GrossVolume: 28.2562 m3; NetVolume: 28.2562 m3

# IfcSpace: A 1102:1671892, 1102
In: 03 derde verdieping
LongName: Trappenhuis; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1102
Pset_SpaceHeaterTypeCommon - Reference: A 1102
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 43.032 m3

# IfcSpace: A 1103:1671893, 1103
In: 03 derde verdieping
LongName: Liftschacht; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1103
Pset_SpaceHeaterTypeCommon - Reference: A 1103
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1104:1671894, 1104
In: 03 derde verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1104
Pset_SpaceHeaterTypeCommon - Reference: A 1104
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1105:1671895, 1105
In: 03 derde verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1105
Pset_SpaceHeaterTypeCommon - Reference: A 1105
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1106:1671898, 1106
In: 04 vierde verdieping
LongName: Lifthal; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1106
Pset_SpaceHeaterTypeCommon - Reference: A 1106
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; GrossVolume: 28.2562 m3; NetVolume: 28.2562 m3

# IfcSpace: A 1107:1671899, 1107
In: 04 vierde verdieping
LongName: Trappenhuis; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1107
Pset_SpaceHeaterTypeCommon - Reference: A 1107
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 43.032 m3

# IfcSpace: A 1108:1671900, 1108
In: 04 vierde verdieping
LongName: Liftschacht; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1108
Pset_SpaceHeaterTypeCommon - Reference: A 1108
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1109:1671901, 1109
In: 04 vierde verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1109
Pset_SpaceHeaterTypeCommon - Reference: A 1109
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1110:1671902, 1110
In: 04 vierde verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1110
Pset_SpaceHeaterTypeCommon - Reference: A 1110
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1111:1671905, 1111
In: 05 vijfde verdieping
LongName: Lifthal; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1111
Pset_SpaceHeaterTypeCommon - Reference: A 1111
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; GrossVolume: 28.2562 m3; NetVolume: 28.2562 m3

# IfcSpace: A 1112:1671906, 1112
In: 05 vijfde verdieping
LongName: Trappenhuis; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1112
Pset_SpaceHeaterTypeCommon - Reference: A 1112
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 43.032 m3

# IfcSpace: A 1113:1671907, 1113
In: 05 vijfde verdieping
LongName: Liftschacht; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1113
Pset_SpaceHeaterTypeCommon - Reference: A 1113
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1114:1671908, 1114
In: 05 vijfde verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1114
Pset_SpaceHeaterTypeCommon - Reference: A 1114
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1115:1671909, 1115
In: 05 vijfde verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1115
Pset_SpaceHeaterTypeCommon - Reference: A 1115
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1116:1671912, 1116
In: 06 zesde verdieping
LongName: Lifthal; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1116
Pset_SpaceHeaterTypeCommon - Reference: A 1116
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; GrossVolume: 28.2562 m3; NetVolume: 28.2562 m3

# IfcSpace: A 1117:1671913, 1117
In: 06 zesde verdieping
LongName: Trappenhuis; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1117
Pset_SpaceHeaterTypeCommon - Reference: A 1117
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 43.032 m3

# IfcSpace: A 1118:1671914, 1118
In: 06 zesde verdieping
LongName: Liftschacht; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1118
Pset_SpaceHeaterTypeCommon - Reference: A 1118
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1119:1671915, 1119
In: 06 zesde verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1119
Pset_SpaceHeaterTypeCommon - Reference: A 1119
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1120:1671916, 1120
In: 06 zesde verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1120
Pset_SpaceHeaterTypeCommon - Reference: A 1120
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1121:1671919, 1121
In: 07 zevende verdieping
LongName: Lifthal; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1121
Pset_SpaceHeaterTypeCommon - Reference: A 1121
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; NetVolume: 28.2562 m3

# IfcSpace: A 1122:1671920, 1122
In: 07 zevende verdieping
LongName: Trappenhuis; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1122
Pset_SpaceHeaterTypeCommon - Reference: A 1122
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 43.032 m3

# IfcSpace: A 1123:1671921, 1123
In: 07 zevende verdieping
LongName: Liftschacht; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1123
Pset_SpaceHeaterTypeCommon - Reference: A 1123
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1124:1671922, 1124
In: 07 zevende verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1124
Pset_SpaceHeaterTypeCommon - Reference: A 1124
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1125:1671923, 1125
In: 07 zevende verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1125
Pset_SpaceHeaterTypeCommon - Reference: A 1125
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1126:1671926, 1126
In: 07 zevende verdieping
LongName: Lifthal; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1126
Pset_SpaceHeaterTypeCommon - Reference: A 1126
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; GrossVolume: 28.2562 m3; NetVolume: 28.2562 m3

# IfcSpace: A 1127:1671927, 1127
In: 07 zevende verdieping
LongName: Trappenhuis; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1127
Pset_SpaceHeaterTypeCommon - Reference: A 1127
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 43.032 m3

# IfcSpace: A 1128:1671928, 1128
In: 07 zevende verdieping
LongName: Liftschacht; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1128
Pset_SpaceHeaterTypeCommon - Reference: A 1128
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1129:1671929, 1129
In: 07 zevende verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1129
Pset_SpaceHeaterTypeCommon - Reference: A 1129
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1130:1671930, 1130
In: 07 zevende verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1130
Pset_SpaceHeaterTypeCommon - Reference: A 1130
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1131:1671933, 1131
In: 08 achtste verdieping
LongName: Lifthal; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1131
Pset_SpaceHeaterTypeCommon - Reference: A 1131
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; NetVolume: 28.2562 m3

# IfcSpace: A 1132:1671934, 1132
In: 08 achtste verdieping
LongName: Trappenhuis; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1132
Pset_SpaceHeaterTypeCommon - Reference: A 1132
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.224 m2; NetFloorArea: 7.224 m2; GrossCeilingArea: 7.224 m2; NetVolume: 19.866 m3

# IfcSpace: A 1133:1671935, 1133
In: 08 achtste verdieping
LongName: Liftschacht; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1133
Pset_SpaceHeaterTypeCommon - Reference: A 1133
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1134:1671936, 1134
In: 08 achtste verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1134
Pset_SpaceHeaterTypeCommon - Reference: A 1134
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1135:1671937, 1135
In: 08 achtste verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1135
Pset_SpaceHeaterTypeCommon - Reference: A 1135
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1136:1671940, 1136
In: 08 achtste verdieping
LongName: Lifthal; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1136
Pset_SpaceHeaterTypeCommon - Reference: A 1136
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; GrossVolume: 28.2562 m3; NetVolume: 28.2562 m3

# IfcSpace: A 1137:1671941, 1137
In: 08 achtste verdieping
LongName: Trappenhuis; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1137
Pset_SpaceHeaterTypeCommon - Reference: A 1137
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.224 m2; NetFloorArea: 7.224 m2; GrossCeilingArea: 7.224 m2; GrossVolume: 19.866 m3; NetVolume: 19.866 m3

# IfcSpace: A 1138:1671942, 1138
In: 08 achtste verdieping
LongName: Liftschacht; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1138
Pset_SpaceHeaterTypeCommon - Reference: A 1138
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1139:1671943, 1139
In: 08 achtste verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1139
Pset_SpaceHeaterTypeCommon - Reference: A 1139
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1140:1671944, 1140
In: 08 achtste verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1140
Pset_SpaceHeaterTypeCommon - Reference: A 1140
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1141:1679605, 1141
In: 01 eerste verdieping
LongName: Lifthal; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1141
Pset_SpaceHeaterTypeCommon - Reference: A 1141
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; NetVolume: 28.2563 m3

# IfcSpace: A 1142:1679606, 1142
In: 01 eerste verdieping
LongName: Trappenhuis; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1142
Pset_SpaceHeaterTypeCommon - Reference: A 1142
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 43.032 m3

# IfcSpace: A 1143:1679607, 1143
In: 01 eerste verdieping
LongName: Liftschacht; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1143
Pset_SpaceHeaterTypeCommon - Reference: A 1143
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1144:1679608, 1144
In: 01 eerste verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1144
Pset_SpaceHeaterTypeCommon - Reference: A 1144
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1145:1679609, 1145
In: 01 eerste verdieping
LongName: Corridor; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1145
Pset_SpaceHeaterTypeCommon - Reference: A 1145
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1146:1679706, 1146
In: 01 eerste verdieping
LongName: Lifthal; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1146
Pset_SpaceHeaterTypeCommon - Reference: A 1146
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.275 m2; NetFloorArea: 10.275 m2; GrossCeilingArea: 10.275 m2; GrossVolume: 28.2563 m3; NetVolume: 28.2563 m3

# IfcSpace: A 1147:1679707, 1147
In: 01 eerste verdieping
LongName: Trappenhuis; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1147
Pset_SpaceHeaterTypeCommon - Reference: A 1147
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 43.032 m3

# IfcSpace: A 1148:1679708, 1148
In: 01 eerste verdieping
LongName: Liftschacht; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1148
Pset_SpaceHeaterTypeCommon - Reference: A 1148
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 28.875 m3; NetVolume: 28.875 m3

# IfcSpace: A 1149:1679709, 1149
In: 01 eerste verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1149
Pset_SpaceHeaterTypeCommon - Reference: A 1149
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1150:1679710, 1150
In: 01 eerste verdieping
LongName: Corridor; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1150
Pset_SpaceHeaterTypeCommon - Reference: A 1150
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Corridor
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 2.25 m2; NetFloorArea: 2.25 m2; GrossCeilingArea: 2.25 m2; GrossVolume: 6.1875 m3; NetVolume: 6.1875 m3

# IfcSpace: A 1151:1679791, 1151
In: 08 achtste verdieping
LongName: Trappenhuis; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1151
Pset_SpaceHeaterTypeCommon - Reference: A 1151
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 06; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.224 m2; NetFloorArea: 7.224 m2; GrossCeilingArea: 7.224 m2; NetVolume: 19.866 m3

# IfcSpace: A 1152:1679808, 1152
In: 08 achtste verdieping
LongName: Trappenhuis; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1152
Pset_SpaceHeaterTypeCommon - Reference: A 1152
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 06; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.224 m2; NetFloorArea: 7.224 m2; GrossCeilingArea: 7.224 m2; GrossVolume: 19.866 m3; NetVolume: 19.866 m3

# IfcSpace: A 1297:1681879, 1297
In: 00 begane grond
LongName: Stalling inpandig; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1297
Pset_SpaceHeaterTypeCommon - Reference: A 1297
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Stalling inpandig
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 98.925 m2; NetFloorArea: 98.925 m2; GrossCeilingArea: 98.925 m2; NetVolume: 361.237 m3

# IfcSpace: A 1298:1681960, 1298
In: 00 begane grond
LongName: Lifthal; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1298
Pset_SpaceHeaterTypeCommon - Reference: A 1298
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 57.8912 m2; NetFloorArea: 57.8912 m2; GrossCeilingArea: 57.8912 m2; NetVolume: 211.431 m3

# IfcSpace: A 1299:1681975, 1299
In: 00 begane grond
LongName: Entree; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1299
Pset_SpaceHeaterTypeCommon - Reference: A 1299
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Entree
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 14.2463 m2; NetFloorArea: 14.2463 m2; GrossCeilingArea: 14.2463 m2; NetVolume: 52.1263 m3

# IfcSpace: A 1300:1682005, 1300
In: 00 begane grond
LongName: Huiskamer; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1300
Pset_SpaceHeaterTypeCommon - Reference: A 1300
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 04; RuimteSoort: Verblijfsruimte; RuimteType: Huiskamer; Orientatie: Oost
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 72.8625 m2; NetFloorArea: 72.8625 m2; GrossCeilingArea: 72.8625 m2; NetVolume: 266.203 m3

# IfcSpace: A 1301:1682020, 1301
In: 00 begane grond
LongName: Trappenhuis; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1301
Pset_SpaceHeaterTypeCommon - Reference: A 1301
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 15.924 m2; NetFloorArea: 15.924 m2; GrossCeilingArea: 15.924 m2; NetVolume: 59.1126 m3

# IfcSpace: A 1302:1682035, 1302
In: 00 begane grond
LongName: Technische ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1302
Pset_SpaceHeaterTypeCommon - Reference: A 1302
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 06; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 4.82125 m2; NetFloorArea: 4.82125 m2; GrossCeilingArea: 4.82125 m2; GrossVolume: 17.5976 m3; NetVolume: 17.5976 m3

# IfcSpace: A 1303:1682050, 1303
In: 00 begane grond
LongName: Technische ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1303
Pset_SpaceHeaterTypeCommon - Reference: A 1303
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 07; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 2.8785 m2; NetFloorArea: 2.8785 m2; GrossCeilingArea: 2.8785 m2; NetVolume: 10.5065 m3

# IfcSpace: A 1304:1682065, 1304
In: 00 begane grond
LongName: Technische ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1304
Pset_SpaceHeaterTypeCommon - Reference: A 1304
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 09; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 2.8785 m2; NetFloorArea: 2.8785 m2; GrossCeilingArea: 2.8785 m2; NetVolume: 10.5065 m3

# IfcSpace: A 1305:1682080, 1305
In: 00 begane grond
LongName: Liftschacht; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1305
Pset_SpaceHeaterTypeCommon - Reference: A 1305
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 08; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 37.5375 m3; NetVolume: 37.5375 m3

# IfcSpace: A 1306:1682095, 1306
In: 00 begane grond
LongName: Gang; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1306
Pset_SpaceHeaterTypeCommon - Reference: A 1306
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 10; RuimteSoort: Restruimte; RuimteType: Gang
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 8.88 m2; NetFloorArea: 8.88 m2; GrossCeilingArea: 8.88 m2; GrossVolume: 32.412 m3; NetVolume: 32.412 m3

# IfcSpace: A 1307:1682112, 1307
In: 00 begane grond
LongName: Trappenhuis; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1307
Pset_SpaceHeaterTypeCommon - Reference: A 1307
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 11; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 21.4703 m2; NetFloorArea: 21.4703 m2; GrossCeilingArea: 21.4703 m2; NetVolume: 79.3564 m3

# IfcSpace: A 1308:1682127, 1308
In: 00 begane grond
LongName: Parkeergarage niet-openbaar; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1308
Pset_SpaceHeaterTypeCommon - Reference: A 1308
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 12; RuimteSoort: Restruimte; RuimteType: Parkeergarage niet-openbaar
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 100.125 m2; NetFloorArea: 100.125 m2; GrossCeilingArea: 100.125 m2; NetVolume: 365.617 m3

# IfcSpace: A 1321:1682596, 1321
In: 00 begane grond
LongName: Stalling inpandig; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1321
Pset_SpaceHeaterTypeCommon - Reference: A 1321
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Stalling inpandig
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 98.925 m2; NetFloorArea: 98.925 m2; GrossCeilingArea: 98.925 m2; NetVolume: 361.237 m3

# IfcSpace: A 1322:1682597, 1322
In: 00 begane grond
LongName: Lifthal; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1322
Pset_SpaceHeaterTypeCommon - Reference: A 1322
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Lifthal
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 57.8912 m2; NetFloorArea: 57.8912 m2; GrossCeilingArea: 57.8912 m2; NetVolume: 211.431 m3

# IfcSpace: A 1323:1682598, 1323
In: 00 begane grond
LongName: Entree; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1323
Pset_SpaceHeaterTypeCommon - Reference: A 1323
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Entree
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 14.2463 m2; NetFloorArea: 14.2463 m2; GrossCeilingArea: 14.2463 m2; NetVolume: 52.1263 m3

# IfcSpace: A 1324:1682599, 1324
In: 00 begane grond
