Properties of the parts of a building model (IFC4), part 11 of 12

# IfcSpace: Area:1722155
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.1288 m2; NetFloorArea: 14.1288 m2; GrossCeilingArea: 14.1288 m2

# IfcSpace: Area:1722157
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 23.43 m2; NetFloorArea: 23.43 m2; GrossCeilingArea: 23.43 m2

# IfcSpace: Area:1722159
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.37125 m2; NetFloorArea: 9.37125 m2; GrossCeilingArea: 9.37125 m2

# IfcSpace: Area:1722161
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1387 m2; NetFloorArea: 41.1387 m2; GrossCeilingArea: 41.1387 m2

# IfcSpace: Area:1722163
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 18.7533 m2; NetFloorArea: 18.7533 m2; GrossCeilingArea: 18.7533 m2

# IfcSpace: Area:1722165
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 54.7993 m2; NetFloorArea: 54.7993 m2; GrossCeilingArea: 54.7993 m2

# IfcSpace: Area:1722167
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 16.4025 m2; NetFloorArea: 16.4025 m2; GrossCeilingArea: 16.4025 m2

# IfcSpace: Area:1722169
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.62825 m2; NetFloorArea: 4.62825 m2; GrossCeilingArea: 4.62825 m2

# IfcSpace: Area:1722171
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1722173
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 13.6525 m2; NetFloorArea: 13.6525 m2; GrossCeilingArea: 13.6525 m2

# IfcSpace: Area:1722175
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.06.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.92 m2; NetFloorArea: 22.92 m2; GrossCeilingArea: 22.92 m2

# IfcSpace: Area:1722177
In: 06 zesde verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1722182
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1388 m2; NetFloorArea: 41.1388 m2; GrossCeilingArea: 41.1388 m2

# IfcSpace: Area:1722184
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.9225 m2; NetFloorArea: 9.9225 m2; GrossCeilingArea: 9.9225 m2

# IfcSpace: Area:1722186
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.8875 m2; NetFloorArea: 22.8875 m2; GrossCeilingArea: 22.8875 m2

# IfcSpace: Area:1722188
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 57.617 m2; NetFloorArea: 57.617 m2; GrossCeilingArea: 57.617 m2

# IfcSpace: Area:1722190
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.43 m2; NetFloorArea: 14.43 m2; GrossCeilingArea: 14.43 m2

# IfcSpace: Area:1722192
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.79625 m2; NetFloorArea: 7.79625 m2; GrossCeilingArea: 7.79625 m2

# IfcSpace: Area:1722194
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1722196
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.1288 m2; NetFloorArea: 14.1288 m2; GrossCeilingArea: 14.1288 m2

# IfcSpace: Area:1722198
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 23.43 m2; NetFloorArea: 23.43 m2; GrossCeilingArea: 23.43 m2

# IfcSpace: Area:1722200
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.37125 m2; NetFloorArea: 9.37125 m2; GrossCeilingArea: 9.37125 m2

# IfcSpace: Area:1722202
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1387 m2; NetFloorArea: 41.1387 m2; GrossCeilingArea: 41.1387 m2

# IfcSpace: Area:1722204
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 18.7533 m2; NetFloorArea: 18.7533 m2; GrossCeilingArea: 18.7533 m2

# IfcSpace: Area:1722206
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 54.8345 m2; NetFloorArea: 54.8345 m2; GrossCeilingArea: 54.8345 m2

# IfcSpace: Area:1722208
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 16.4025 m2; NetFloorArea: 16.4025 m2; GrossCeilingArea: 16.4025 m2

# IfcSpace: Area:1722210
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.62825 m2; NetFloorArea: 4.62825 m2; GrossCeilingArea: 4.62825 m2

# IfcSpace: Area:1722212
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1722214
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 13.6525 m2; NetFloorArea: 13.6525 m2; GrossCeilingArea: 13.6525 m2

# IfcSpace: Area:1722216
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.07.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.92 m2; NetFloorArea: 22.92 m2; GrossCeilingArea: 22.92 m2

# IfcSpace: Area:1722218
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1722220
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1388 m2; NetFloorArea: 41.1388 m2; GrossCeilingArea: 41.1388 m2

# IfcSpace: Area:1722222
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.9225 m2; NetFloorArea: 9.9225 m2; GrossCeilingArea: 9.9225 m2

# IfcSpace: Area:1722224
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.8875 m2; NetFloorArea: 22.8875 m2; GrossCeilingArea: 22.8875 m2

# IfcSpace: Area:1722226
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 57.617 m2; NetFloorArea: 57.617 m2; GrossCeilingArea: 57.617 m2

# IfcSpace: Area:1722228
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.43 m2; NetFloorArea: 14.43 m2; GrossCeilingArea: 14.43 m2

# IfcSpace: Area:1722230
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 7.79625 m2; NetFloorArea: 7.79625 m2; GrossCeilingArea: 7.79625 m2

# IfcSpace: Area:1722232
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1722234
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 14.1288 m2; NetFloorArea: 14.1288 m2; GrossCeilingArea: 14.1288 m2

# IfcSpace: Area:1722236
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 23.43 m2; NetFloorArea: 23.43 m2; GrossCeilingArea: 23.43 m2

# IfcSpace: Area:1722238
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 9.37125 m2; NetFloorArea: 9.37125 m2; GrossCeilingArea: 9.37125 m2

# IfcSpace: Area:1722240
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.1387 m2; NetFloorArea: 41.1387 m2; GrossCeilingArea: 41.1387 m2

# IfcSpace: Area:1722242
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 18.7533 m2; NetFloorArea: 18.7533 m2; GrossCeilingArea: 18.7533 m2

# IfcSpace: Area:1722244
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 54.7993 m2; NetFloorArea: 54.7993 m2; GrossCeilingArea: 54.7993 m2

# IfcSpace: Area:1722246
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 16.4025 m2; NetFloorArea: 16.4025 m2; GrossCeilingArea: 16.4025 m2

# IfcSpace: Area:1722248
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.62825 m2; NetFloorArea: 4.62825 m2; GrossCeilingArea: 4.62825 m2

# IfcSpace: Area:1722250
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 39.2937 m2; NetFloorArea: 39.2937 m2; GrossCeilingArea: 39.2937 m2

# IfcSpace: Area:1722252
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 13.6525 m2; NetFloorArea: 13.6525 m2; GrossCeilingArea: 13.6525 m2

# IfcSpace: Area:1722254
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.07.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 22.92 m2; NetFloorArea: 22.92 m2; GrossCeilingArea: 22.92 m2

# IfcSpace: Area:1722256
In: 07 zevende verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1746594
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Bedgebied; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 56.6563 m2; NetFloorArea: 56.6563 m2; GrossCeilingArea: 56.6563 m2

# IfcSpace: Area:1746615
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Bedgebied; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 56.6563 m2; NetFloorArea: 56.6563 m2; GrossCeilingArea: 56.6563 m2

# IfcSpace: Area:1746631
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 112.645 m2; NetFloorArea: 112.645 m2; GrossCeilingArea: 112.645 m2

# IfcSpace: Area:1746647
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 16.0875 m2; NetFloorArea: 16.0875 m2; GrossCeilingArea: 16.0875 m2

# IfcSpace: Area:1746658
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Bedgebied; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 56.6563 m2; NetFloorArea: 56.6563 m2; GrossCeilingArea: 56.6563 m2

# IfcSpace: Area:1746660
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Bedgebied; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 56.6563 m2; NetFloorArea: 56.6563 m2; GrossCeilingArea: 56.6563 m2

# IfcSpace: Area:1746662
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 28.495 m2; NetFloorArea: 28.495 m2; GrossCeilingArea: 28.495 m2

# IfcSpace: Area:1747504
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 30.025 m2; NetFloorArea: 30.025 m2; GrossCeilingArea: 30.025 m2

# IfcSpace: Area:1747507
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 2.475 m2; NetFloorArea: 2.475 m2; GrossCeilingArea: 2.475 m2

# IfcSpace: Area:1747510
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 9.165 m2; NetFloorArea: 9.165 m2; GrossCeilingArea: 9.165 m2

# IfcSpace: Area:1747588
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 30.025 m2; NetFloorArea: 30.025 m2; GrossCeilingArea: 30.025 m2

# IfcSpace: Area:1747590
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 2.475 m2; NetFloorArea: 2.475 m2; GrossCeilingArea: 2.475 m2

# IfcSpace: Area:1747592
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 9.165 m2; NetFloorArea: 9.165 m2; GrossCeilingArea: 9.165 m2

# IfcSpace: Area:1747599
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 30.025 m2; NetFloorArea: 30.025 m2; GrossCeilingArea: 30.025 m2

# IfcSpace: Area:1747601
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 2.475 m2; NetFloorArea: 2.475 m2; GrossCeilingArea: 2.475 m2

# IfcSpace: Area:1747603
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 9.165 m2; NetFloorArea: 9.165 m2; GrossCeilingArea: 9.165 m2

# IfcSpace: Area:1747623
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 30.025 m2; NetFloorArea: 30.025 m2; GrossCeilingArea: 30.025 m2

# IfcSpace: Area:1747625
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 2.475 m2; NetFloorArea: 2.475 m2; GrossCeilingArea: 2.475 m2

# IfcSpace: Area:1747627
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 9.165 m2; NetFloorArea: 9.165 m2; GrossCeilingArea: 9.165 m2

# IfcSpace: Area:1747629
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 30.025 m2; NetFloorArea: 30.025 m2; GrossCeilingArea: 30.025 m2

# IfcSpace: Area:1747631
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 2.475 m2; NetFloorArea: 2.475 m2; GrossCeilingArea: 2.475 m2

# IfcSpace: Area:1747633
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 9.165 m2; NetFloorArea: 9.165 m2; GrossCeilingArea: 9.165 m2

# IfcSpace: Area:1747634
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 30.025 m2; NetFloorArea: 30.025 m2; GrossCeilingArea: 30.025 m2

# IfcSpace: Area:1747636
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 2.475 m2; NetFloorArea: 2.475 m2; GrossCeilingArea: 2.475 m2

# IfcSpace: Area:1747638
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 9.165 m2; NetFloorArea: 9.165 m2; GrossCeilingArea: 9.165 m2

# IfcSpace: Area:1747641
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 30.025 m2; NetFloorArea: 30.025 m2; GrossCeilingArea: 30.025 m2

# IfcSpace: Area:1747643
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 2.475 m2; NetFloorArea: 2.475 m2; GrossCeilingArea: 2.475 m2

# IfcSpace: Area:1747645
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 9.165 m2; NetFloorArea: 9.165 m2; GrossCeilingArea: 9.165 m2

# IfcSpace: Area:1747647
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 30.025 m2; NetFloorArea: 30.025 m2; GrossCeilingArea: 30.025 m2

# IfcSpace: Area:1747649
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 2.475 m2; NetFloorArea: 2.475 m2; GrossCeilingArea: 2.475 m2

# IfcSpace: Area:1747651
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 9.165 m2; NetFloorArea: 9.165 m2; GrossCeilingArea: 9.165 m2

# IfcSpace: Area:1747652
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 30.025 m2; NetFloorArea: 30.025 m2; GrossCeilingArea: 30.025 m2

# IfcSpace: Area:1747654
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 2.475 m2; NetFloorArea: 2.475 m2; GrossCeilingArea: 2.475 m2

# IfcSpace: Area:1747656
In: 00 begane grond
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 9.165 m2; NetFloorArea: 9.165 m2; GrossCeilingArea: 9.165 m2

# IfcSpace: Area:1747659
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.48 m2; NetFloorArea: 31.48 m2; GrossCeilingArea: 31.48 m2

# IfcSpace: Area:1747660
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.3275 m2; NetFloorArea: 10.3275 m2; GrossCeilingArea: 10.3275 m2

# IfcSpace: Area:1747661
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.48 m2; NetFloorArea: 31.48 m2; GrossCeilingArea: 31.48 m2

# IfcSpace: Area:1747662
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.3275 m2; NetFloorArea: 10.3275 m2; GrossCeilingArea: 10.3275 m2

# IfcSpace: Area:1747663
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.48 m2; NetFloorArea: 31.48 m2; GrossCeilingArea: 31.48 m2

# IfcSpace: Area:1747664
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.3275 m2; NetFloorArea: 10.3275 m2; GrossCeilingArea: 10.3275 m2

# IfcSpace: Area:1747665
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.48 m2; NetFloorArea: 31.48 m2; GrossCeilingArea: 31.48 m2

# IfcSpace: Area:1747666
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.3275 m2; NetFloorArea: 10.3275 m2; GrossCeilingArea: 10.3275 m2

# IfcSpace: Area:1747667
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.48 m2; NetFloorArea: 31.48 m2; GrossCeilingArea: 31.48 m2

# IfcSpace: Area:1747668
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.3275 m2; NetFloorArea: 10.3275 m2; GrossCeilingArea: 10.3275 m2

# IfcSpace: Area:1747669
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.48 m2; NetFloorArea: 31.48 m2; GrossCeilingArea: 31.48 m2

# IfcSpace: Area:1747670
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.3275 m2; NetFloorArea: 10.3275 m2; GrossCeilingArea: 10.3275 m2

# IfcSpace: Area:1747671
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.48 m2; NetFloorArea: 31.48 m2; GrossCeilingArea: 31.48 m2

# IfcSpace: Area:1747672
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.3275 m2; NetFloorArea: 10.3275 m2; GrossCeilingArea: 10.3275 m2

# IfcSpace: Area:1747673
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.48 m2; NetFloorArea: 31.48 m2; GrossCeilingArea: 31.48 m2

# IfcSpace: Area:1747674
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.3275 m2; NetFloorArea: 10.3275 m2; GrossCeilingArea: 10.3275 m2

# IfcSpace: Area:1747675
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 31.48 m2; NetFloorArea: 31.48 m2; GrossCeilingArea: 31.48 m2

# IfcSpace: Area:1747676
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.00.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 10.3275 m2; NetFloorArea: 10.3275 m2; GrossCeilingArea: 10.3275 m2

# IfcSpace: Area:1747707
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.8907 m2; NetFloorArea: 15.8907 m2; GrossCeilingArea: 15.8907 m2

# IfcSpace: Area:1747717
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.675 m2; NetFloorArea: 4.675 m2; GrossCeilingArea: 4.675 m2

# IfcSpace: Area:1747745
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 64.0525 m2; NetFloorArea: 64.0525 m2; GrossCeilingArea: 64.0525 m2

# IfcSpace: Area:1747757
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 19.8087 m2; NetFloorArea: 19.8087 m2; GrossCeilingArea: 19.8087 m2

# IfcSpace: Area:1747759
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.675 m2; NetFloorArea: 4.675 m2; GrossCeilingArea: 4.675 m2

# IfcSpace: Area:1747761
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 64.0525 m2; NetFloorArea: 64.0525 m2; GrossCeilingArea: 64.0525 m2

# IfcSpace: Area:1747765
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 19.8087 m2; NetFloorArea: 19.8087 m2; GrossCeilingArea: 19.8087 m2

# IfcSpace: Area:1747767
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.675 m2; NetFloorArea: 4.675 m2; GrossCeilingArea: 4.675 m2

# IfcSpace: Area:1747769
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 64.0525 m2; NetFloorArea: 64.0525 m2; GrossCeilingArea: 64.0525 m2

# IfcSpace: Area:1747777
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.4408 m2; NetFloorArea: 15.4408 m2; GrossCeilingArea: 15.4408 m2

# IfcSpace: Area:1747779
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.675 m2; NetFloorArea: 4.675 m2; GrossCeilingArea: 4.675 m2

# IfcSpace: Area:1747781
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01; 01.01.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 64.0525 m2; NetFloorArea: 64.0525 m2; GrossCeilingArea: 64.0525 m2

# IfcSpace: Area:1747786
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 41.826 m2; NetFloorArea: 40.268 m2; GrossCeilingArea: 41.826 m2

# IfcSpace: Area:1747790
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 15.8907 m2; NetFloorArea: 15.8907 m2; GrossCeilingArea: 15.8907 m2

# IfcSpace: Area:1747792
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Restgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 4.675 m2; NetFloorArea: 4.675 m2; GrossCeilingArea: 4.675 m2

# IfcSpace: Area:1747794
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Verblijfsgebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 64.0525 m2; NetFloorArea: 64.0525 m2; GrossCeilingArea: 64.0525 m2

# IfcSpace: Area:1747796
In: 01 eerste verdieping
Type - PredefinedType: USERDEFINED
LongName: Area; Group: 02; 02.01.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
