Properties of the parts of a building model (IFC4), part 6 of 12

# IfcSpace: A 1324:1682599, 1324
LongName: Huiskamer; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1324
Pset_SpaceHeaterTypeCommon - Reference: A 1324
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 04; RuimteSoort: Verblijfsruimte; RuimteType: Huiskamer; Orientatie: West
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 72.8625 m2; NetFloorArea: 72.8625 m2; GrossCeilingArea: 72.8625 m2; NetVolume: 266.203 m3

# IfcSpace: A 1325:1682600, 1325
In: 00 begane grond
LongName: Trappenhuis; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1325
Pset_SpaceHeaterTypeCommon - Reference: A 1325
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 21.4703 m2; NetFloorArea: 21.4703 m2; GrossCeilingArea: 21.4703 m2; NetVolume: 79.3564 m3

# IfcSpace: A 1326:1682601, 1326
In: 00 begane grond
LongName: Technische ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1326
Pset_SpaceHeaterTypeCommon - Reference: A 1326
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 07; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 2.8785 m2; NetFloorArea: 2.8785 m2; GrossCeilingArea: 2.8785 m2; NetVolume: 10.5065 m3

# IfcSpace: A 1327:1682602, 1327
In: 00 begane grond
LongName: Technische ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1327
Pset_SpaceHeaterTypeCommon - Reference: A 1327
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 09; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 2.8785 m2; NetFloorArea: 2.8785 m2; GrossCeilingArea: 2.8785 m2; NetVolume: 10.5065 m3

# IfcSpace: A 1328:1682603, 1328
In: 00 begane grond
LongName: Liftschacht; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1328
Pset_SpaceHeaterTypeCommon - Reference: A 1328
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 08; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 37.5375 m3; NetVolume: 37.5375 m3

# IfcSpace: A 1329:1682604, 1329
In: 00 begane grond
LongName: Gang; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1329
Pset_SpaceHeaterTypeCommon - Reference: A 1329
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 10; RuimteSoort: Restruimte; RuimteType: Gang
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 8.88 m2; NetFloorArea: 8.88 m2; GrossCeilingArea: 8.88 m2; GrossVolume: 32.412 m3; NetVolume: 32.412 m3

# IfcSpace: A 1330:1682605, 1330
In: 00 begane grond
LongName: Trappenhuis; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1330
Pset_SpaceHeaterTypeCommon - Reference: A 1330
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 11; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 21.4703 m2; NetFloorArea: 21.4703 m2; GrossCeilingArea: 21.4703 m2; NetVolume: 79.3564 m3

# IfcSpace: A 1331:1682695, 1331
In: -1 kelder
LongName: Trappenhuis; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1331
Pset_SpaceHeaterTypeCommon - Reference: A 1331
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 16.776 m2; NetFloorArea: 15.984 m2; GrossCeilingArea: 16.776 m2; NetVolume: 49.2648 m3

# IfcSpace: A 1332:1682696, 1332
In: -1 kelder
LongName: Technische ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1332
Pset_SpaceHeaterTypeCommon - Reference: A 1332
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 8.45625 m2; NetFloorArea: 8.45625 m2; GrossCeilingArea: 8.45625 m2; GrossVolume: 24.9459 m3; NetVolume: 24.9459 m3

# IfcSpace: A 1333:1682697, 1333
In: -1 kelder
LongName: Technische ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1333
Pset_SpaceHeaterTypeCommon - Reference: A 1333
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 06; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 8.45625 m2; NetFloorArea: 8.45625 m2; GrossCeilingArea: 8.45625 m2; NetVolume: 24.9459 m3

# IfcSpace: A 1334:1682698, 1334
In: -1 kelder
LongName: Liftschacht; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1334
Pset_SpaceHeaterTypeCommon - Reference: A 1334
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 30.8 m3; NetVolume: 30.8 m3

# IfcSpace: A 1335:1682699, 1335
In: -1 kelder
LongName: Gang; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1335
Pset_SpaceHeaterTypeCommon - Reference: A 1335
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Gang
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 15.2625 m2; NetFloorArea: 15.2625 m2; GrossCeilingArea: 15.2625 m2; NetVolume: 45.0244 m3

# IfcSpace: A 1336:1682700, 1336
In: -1 kelder
LongName: Technische ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1336
Pset_SpaceHeaterTypeCommon - Reference: A 1336
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 06; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 4.7115 m2; NetFloorArea: 4.7115 m2; GrossCeilingArea: 4.7115 m2; GrossVolume: 13.8989 m3; NetVolume: 13.8989 m3

# IfcSpace: A 1337:1682717, 1337
In: -1 kelder
LongName: Technische ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: A 1337
Pset_SpaceHeaterTypeCommon - Reference: A 1337
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 01; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 4.7115 m2; NetFloorArea: 4.7115 m2; GrossCeilingArea: 4.7115 m2; GrossVolume: 13.8989 m3; NetVolume: 13.8989 m3

# IfcSpace: A 1345:1682830, 1345
In: -1 kelder
LongName: Trappenhuis; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1345
Pset_SpaceHeaterTypeCommon - Reference: A 1345
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 03; RuimteSoort: Restruimte; RuimteType: Trappenhuis
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 15.632 m2; NetFloorArea: 14.928 m2; GrossCeilingArea: 15.632 m2; NetVolume: 46.0176 m3

# IfcSpace: A 1346:1682831, 1346
In: -1 kelder
LongName: Technische ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1346
Pset_SpaceHeaterTypeCommon - Reference: A 1346
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 05; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 8.45625 m2; NetFloorArea: 8.45625 m2; GrossCeilingArea: 8.45625 m2; GrossVolume: 24.9459 m3; NetVolume: 24.9459 m3

# IfcSpace: A 1347:1682832, 1347
In: -1 kelder
LongName: Technische ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1347
Pset_SpaceHeaterTypeCommon - Reference: A 1347
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 06; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 8.45625 m2; NetFloorArea: 8.45625 m2; GrossCeilingArea: 8.45625 m2; NetVolume: 24.9459 m3

# IfcSpace: A 1348:1682833, 1348
In: -1 kelder
LongName: Liftschacht; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1348
Pset_SpaceHeaterTypeCommon - Reference: A 1348
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Liftschacht
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 9.625 m2; NetFloorArea: 9.625 m2; GrossCeilingArea: 9.625 m2; GrossVolume: 30.8 m3; NetVolume: 30.8 m3

# IfcSpace: A 1349:1682834, 1349
In: -1 kelder
LongName: Gang; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1349
Pset_SpaceHeaterTypeCommon - Reference: A 1349
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Gang
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 15.075 m2; NetFloorArea: 15.075 m2; GrossCeilingArea: 15.075 m2; GrossVolume: 44.4713 m3; NetVolume: 44.4713 m3

# IfcSpace: A 1350:1682835, 1350
In: -1 kelder
LongName: Technische ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1350
Pset_SpaceHeaterTypeCommon - Reference: A 1350
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 06; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 5.3055 m2; NetFloorArea: 5.3055 m2; GrossCeilingArea: 5.3055 m2; NetVolume: 15.6512 m3

# IfcSpace: A 1351:1682836, 1351
In: -1 kelder
LongName: Technische ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: A 1351
Pset_SpaceHeaterTypeCommon - Reference: A 1351
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 02; RuimteNummer: 04; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 5.3055 m2; NetFloorArea: 5.3055 m2; GrossCeilingArea: 5.3055 m2; NetVolume: 15.6512 m3

# IfcSpace: A 1352:1685073, 1352
In: -1 kelder
LongName: Parkeergarage niet-openbaar; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: A 1352
Pset_SpaceHeaterTypeCommon - Reference: A 1352
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 00; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Parkeergarage niet-openbaar
Qto_SpaceBaseQuantities - Height: 2.95 m; GrossFloorArea: 1789.58 m2; NetFloorArea: 1690.86 m2; GrossCeilingArea: 1789.58 m2; GrossVolume: 5279.25 m3; NetVolume: 4988.05 m3

# IfcSpace: A 1353:1685378, 1353
In: -1 kelder
LongName: Technische ruimte; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: A 1353
Pset_SpaceHeaterTypeCommon - Reference: A 1353
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 00; RuimteNummer: 24; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 9.12 m2; NetFloorArea: 9.12 m2; GrossCeilingArea: 9.12 m2; NetVolume: 26.904 m3

# IfcSpace: A 1354:1685397, 1354
In: -1 kelder
LongName: Gang; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: A 1354
Pset_SpaceHeaterTypeCommon - Reference: A 1354
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 00; RuimteNummer: 23; RuimteSoort: Restruimte; RuimteType: Gang
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 25.2675 m2; NetFloorArea: 25.2675 m2; GrossCeilingArea: 25.2675 m2; NetVolume: 74.5391 m3

# IfcSpace: A 1355:1685437, 1355
In: -1 kelder
LongName: Technische ruimte; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: A 1355
Pset_SpaceHeaterTypeCommon - Reference: A 1355
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 00; RuimteNummer: 25; RuimteSoort: Restruimte; RuimteType: Technische ruimte
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 8.64 m2; NetFloorArea: 8.64 m2; GrossCeilingArea: 8.64 m2; GrossVolume: 25.488 m3; NetVolume: 25.488 m3

# IfcSpace: A 1356:1685452, 1356
In: -1 kelder
LongName: Fietsenstalling inpandig; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: A 1356
Pset_SpaceHeaterTypeCommon - Reference: A 1356
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 00; RuimteNummer: 22; RuimteSoort: Restruimte; RuimteType: Fietsenstalling inpandig
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 141.488 m2; NetFloorArea: 141.488 m2; GrossCeilingArea: 141.488 m2; NetVolume: 419.291 m3

# IfcSpace: A 1358:1685486, 1358
In: -1 kelder
LongName: Gang; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: A 1358
Pset_SpaceHeaterTypeCommon - Reference: A 1358
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 00; RuimteNummer: 06; RuimteSoort: Restruimte; RuimteType: Gang
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 15.015 m2; NetFloorArea: 15.015 m2; GrossCeilingArea: 15.015 m2; GrossVolume: 44.2942 m3; NetVolume: 44.2942 m3

# IfcSpace: A 1374:1686517, 1374
In: -1 kelder
LongName: Fietsenstalling inpandig; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: A 1374
Pset_SpaceHeaterTypeCommon - Reference: A 1374
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 00; RuimteNummer: 01; RuimteSoort: Restruimte; RuimteType: Fietsenstalling inpandig
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 141.488 m2; NetFloorArea: 141.488 m2; GrossCeilingArea: 141.488 m2; NetVolume: 419.291 m3

# IfcSpace: A 1376:1688459, 1376
In: -1 kelder
LongName: Gang; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: A 1376
Pset_SpaceHeaterTypeCommon - Reference: A 1376
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 00; RuimteNummer: 02; RuimteSoort: Restruimte; RuimteType: Gang
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 21.505 m2; NetFloorArea: 21.505 m2; GrossCeilingArea: 21.505 m2; GrossVolume: 63.4397 m3; NetVolume: 63.4397 m3

# IfcSpace: Area:1483567
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.08.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.08.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSK; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 83.002 m2; NetFloorArea: 83.002 m2; GrossCeilingArea: 83.002 m2

# IfcSpace: Area:1483574
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.01.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.01.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: D
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 100.965 m2; NetFloorArea: 100.965 m2; GrossCeilingArea: 100.965 m2

# IfcSpace: Area:1483611
In: 00 begane grond
LongName: Gebruiksfunctie; Group: 02; 02.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Kinderdagverblijf; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 276.114 m2; NetFloorArea: 276.114 m2; GrossCeilingArea: 276.114 m2

# IfcSpace: Area:1483627
In: 00 begane grond
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Bijeenkomstfunctie, Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 16.9595 m2; NetFloorArea: 16.9595 m2; GrossCeilingArea: 16.9595 m2

# IfcSpace: Area:1483717
In: 00 begane grond
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Parkeergarage stalling; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 110.912 m2; NetFloorArea: 110.912 m2; GrossCeilingArea: 110.912 m2

# IfcSpace: Area:1484199
In: -1 kelder
LongName: Gemeenschappelijke ruimte; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 00; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Fietsenstalling inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 454.266 m2; NetFloorArea: 454.266 m2; GrossCeilingArea: 454.266 m2

# IfcSpace: Area:1484202
In: -1 kelder
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 77.25 m2; NetFloorArea: 77.25 m2; GrossCeilingArea: 77.25 m2

# IfcSpace: Area:1484208
In: -1 kelder
LongName: Gemeenschappelijke ruimte; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 00; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Parkeergarage stalling; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 1849.32 m2; NetFloorArea: 1772.07 m2; GrossCeilingArea: 1849.32 m2

# IfcSpace: Area:1484238
In: -1 kelder
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 77.25 m2; NetFloorArea: 77.25 m2; GrossCeilingArea: 77.25 m2

# IfcSpace: Area:1488725
In: 00 begane grond
LongName: Gemeenschappelijk verblijfsgebied; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijk verblijfsgebied; GebiedsType: Huiskamer; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 81.6275 m2; NetFloorArea: 81.6275 m2; GrossCeilingArea: 81.6275 m2

# IfcSpace: Area:1488741
In: 00 begane grond
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 141.918 m2; NetFloorArea: 141.918 m2; GrossCeilingArea: 141.918 m2

# IfcSpace: Area:1488759
In: 00 begane grond
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Fietsenstalling inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 110.913 m2; NetFloorArea: 110.913 m2; GrossCeilingArea: 110.913 m2

# IfcSpace: Area:1488792
In: 00 begane grond
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Fietsenstalling inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 110.912 m2; NetFloorArea: 110.912 m2; GrossCeilingArea: 110.912 m2

# IfcSpace: Area:1488824
In: 00 begane grond
LongName: Gemeenschappelijk verblijfsgebied; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijk verblijfsgebied; GebiedsType: Huiskamer; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 81.6275 m2; NetFloorArea: 81.6275 m2; GrossCeilingArea: 81.6275 m2

# IfcSpace: Area:1488842
In: 00 begane grond
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 158.877 m2; NetFloorArea: 158.877 m2; GrossCeilingArea: 158.877 m2

# IfcSpace: Area:1489604
In: 01 eerste verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490290
In: 01 eerste verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490786
In: 08 achtste verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490931
In: -1 kelder
LongName: Gemeenschappelijke ruimte; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 00; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Berging inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 85.5938 m2; NetFloorArea: 85.5938 m2; GrossCeilingArea: 85.5938 m2

# IfcSpace: Area:1490997
In: -1 kelder
LongName: Gemeenschappelijke ruimte; Group: 00
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 00; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 43.155 m2; NetFloorArea: 43.155 m2; GrossCeilingArea: 43.155 m2

# IfcSpace: Area:1491128
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.00.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.00.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid; Programma: 4 kamer; Segment: VSK; WoningType: B
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 49.0725 m2; NetFloorArea: 49.0725 m2; GrossCeilingArea: 49.0725 m2

# IfcSpace: Area:1491190
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.00.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Kinderdagverblijf; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 165.201 m2; NetFloorArea: 165.201 m2; GrossCeilingArea: 165.201 m2

# IfcSpace: Area:1699156
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.08.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.08.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSK; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.9 m2; NetFloorArea: 90.9 m2; GrossCeilingArea: 90.9 m2

# IfcSpace: Area:1699168
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.08.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.08.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 91.3625 m2; NetFloorArea: 91.3625 m2; GrossCeilingArea: 91.3625 m2

# IfcSpace: Area:1699178
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.08.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.08.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSK; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 88.035 m2; NetFloorArea: 88.035 m2; GrossCeilingArea: 88.035 m2

# IfcSpace: Area:1699186
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.08.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.08.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSK; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 89.82 m2; NetFloorArea: 89.82 m2; GrossCeilingArea: 89.82 m2

# IfcSpace: Area:1699196
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.08.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.08.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 87.4095 m2; NetFloorArea: 87.4095 m2; GrossCeilingArea: 87.4095 m2

# IfcSpace: Area:1699475
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 01; 01.02.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.02.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSK; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 83.002 m2; NetFloorArea: 83.002 m2; GrossCeilingArea: 83.002 m2

# IfcSpace: Area:1699476
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 01; 01.02.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.02.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSK; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.9 m2; NetFloorArea: 90.9 m2; GrossCeilingArea: 90.9 m2

# IfcSpace: Area:1699477
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 01; 01.02.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.02.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 91.3625 m2; NetFloorArea: 91.3625 m2; GrossCeilingArea: 91.3625 m2

# IfcSpace: Area:1699478
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 01; 01.02.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.02.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSK; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 88.035 m2; NetFloorArea: 88.035 m2; GrossCeilingArea: 88.035 m2

# IfcSpace: Area:1699479
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 01; 01.02.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.02.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSK; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 89.82 m2; NetFloorArea: 89.82 m2; GrossCeilingArea: 89.82 m2

# IfcSpace: Area:1699480
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 01; 01.02.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.02.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 87.4095 m2; NetFloorArea: 87.4095 m2; GrossCeilingArea: 87.4095 m2

# IfcSpace: Area:1699482
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 02; 02.02.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.02.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSH; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 83.002 m2; NetFloorArea: 83.002 m2; GrossCeilingArea: 83.002 m2

# IfcSpace: Area:1699483
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 02; 02.02.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.02.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.9 m2; NetFloorArea: 90.9 m2; GrossCeilingArea: 90.9 m2

# IfcSpace: Area:1699484
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 02; 02.02.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.02.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 91.3625 m2; NetFloorArea: 91.3625 m2; GrossCeilingArea: 91.3625 m2

# IfcSpace: Area:1699485
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 02; 02.02.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.02.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSH; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 88.035 m2; NetFloorArea: 88.035 m2; GrossCeilingArea: 88.035 m2

# IfcSpace: Area:1699486
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 02; 02.02.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.02.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSH; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 89.82 m2; NetFloorArea: 89.82 m2; GrossCeilingArea: 89.82 m2

# IfcSpace: Area:1699487
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 02; 02.02.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.02.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 87.4095 m2; NetFloorArea: 87.4095 m2; GrossCeilingArea: 87.4095 m2

# IfcSpace: Area:1699489
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.03.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.03.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSK; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 83.002 m2; NetFloorArea: 83.002 m2; GrossCeilingArea: 83.002 m2

# IfcSpace: Area:1699490
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.03.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.03.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSK; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.9 m2; NetFloorArea: 90.9 m2; GrossCeilingArea: 90.9 m2

# IfcSpace: Area:1699491
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.03.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.03.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 91.3625 m2; NetFloorArea: 91.3625 m2; GrossCeilingArea: 91.3625 m2

# IfcSpace: Area:1699492
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.03.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.03.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSK; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 88.035 m2; NetFloorArea: 88.035 m2; GrossCeilingArea: 88.035 m2

# IfcSpace: Area:1699493
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.03.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.03.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSK; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 89.82 m2; NetFloorArea: 89.82 m2; GrossCeilingArea: 89.82 m2

# IfcSpace: Area:1699494
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.03.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.03.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 87.4095 m2; NetFloorArea: 87.4095 m2; GrossCeilingArea: 87.4095 m2

# IfcSpace: Area:1699496
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.03.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.03.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSH; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 83.002 m2; NetFloorArea: 83.002 m2; GrossCeilingArea: 83.002 m2

# IfcSpace: Area:1699497
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.03.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.03.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.9 m2; NetFloorArea: 90.9 m2; GrossCeilingArea: 90.9 m2

# IfcSpace: Area:1699498
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.03.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.03.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 91.3625 m2; NetFloorArea: 91.3625 m2; GrossCeilingArea: 91.3625 m2

# IfcSpace: Area:1699499
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.03.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.03.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSH; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 88.035 m2; NetFloorArea: 88.035 m2; GrossCeilingArea: 88.035 m2

# IfcSpace: Area:1699500
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.03.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.03.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSH; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 89.82 m2; NetFloorArea: 89.82 m2; GrossCeilingArea: 89.82 m2

# IfcSpace: Area:1699501
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.03.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.03.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 87.4095 m2; NetFloorArea: 87.4095 m2; GrossCeilingArea: 87.4095 m2

# IfcSpace: Area:1699503
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.04.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.04.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSK; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 83.002 m2; NetFloorArea: 83.002 m2; GrossCeilingArea: 83.002 m2

# IfcSpace: Area:1699504
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.04.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.04.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSK; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.9 m2; NetFloorArea: 90.9 m2; GrossCeilingArea: 90.9 m2

# IfcSpace: Area:1699505
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.04.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.04.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 91.3625 m2; NetFloorArea: 91.3625 m2; GrossCeilingArea: 91.3625 m2

# IfcSpace: Area:1699506
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.04.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.04.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSK; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 88.035 m2; NetFloorArea: 88.035 m2; GrossCeilingArea: 88.035 m2

# IfcSpace: Area:1699507
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.04.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.04.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSK; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 89.82 m2; NetFloorArea: 89.82 m2; GrossCeilingArea: 89.82 m2

# IfcSpace: Area:1699508
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.04.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.04.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 87.4095 m2; NetFloorArea: 87.4095 m2; GrossCeilingArea: 87.4095 m2

# IfcSpace: Area:1699510
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.04.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.04.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSH; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 83.002 m2; NetFloorArea: 83.002 m2; GrossCeilingArea: 83.002 m2

# IfcSpace: Area:1699511
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.04.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.04.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.9 m2; NetFloorArea: 90.9 m2; GrossCeilingArea: 90.9 m2

# IfcSpace: Area:1699512
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.04.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.04.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 91.3625 m2; NetFloorArea: 91.3625 m2; GrossCeilingArea: 91.3625 m2

# IfcSpace: Area:1699513
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.04.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.04.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSH; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 88.035 m2; NetFloorArea: 88.035 m2; GrossCeilingArea: 88.035 m2

# IfcSpace: Area:1699514
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.04.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.04.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSH; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 89.82 m2; NetFloorArea: 89.82 m2; GrossCeilingArea: 89.82 m2

# IfcSpace: Area:1699515
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.04.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.04.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 87.4095 m2; NetFloorArea: 87.4095 m2; GrossCeilingArea: 87.4095 m2

# IfcSpace: Area:1699517
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.05.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.05.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSK; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 83.002 m2; NetFloorArea: 83.002 m2; GrossCeilingArea: 83.002 m2

# IfcSpace: Area:1699518
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.05.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.05.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSK; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.9 m2; NetFloorArea: 90.9 m2; GrossCeilingArea: 90.9 m2

# IfcSpace: Area:1699519
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.05.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.05.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 91.3625 m2; NetFloorArea: 91.3625 m2; GrossCeilingArea: 91.3625 m2

# IfcSpace: Area:1699520
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.05.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.05.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSK; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 88.035 m2; NetFloorArea: 88.035 m2; GrossCeilingArea: 88.035 m2

# IfcSpace: Area:1699521
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.05.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.05.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSK; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 89.82 m2; NetFloorArea: 89.82 m2; GrossCeilingArea: 89.82 m2

# IfcSpace: Area:1699522
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.05.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.05.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 87.4095 m2; NetFloorArea: 87.4095 m2; GrossCeilingArea: 87.4095 m2

# IfcSpace: Area:1699524
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.05.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.05.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSH; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 83.002 m2; NetFloorArea: 83.002 m2; GrossCeilingArea: 83.002 m2

# IfcSpace: Area:1699525
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.05.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.05.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.9 m2; NetFloorArea: 90.9 m2; GrossCeilingArea: 90.9 m2

# IfcSpace: Area:1699526
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.05.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.05.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 91.3625 m2; NetFloorArea: 91.3625 m2; GrossCeilingArea: 91.3625 m2

# IfcSpace: Area:1699527
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.05.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.05.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSH; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 88.035 m2; NetFloorArea: 88.035 m2; GrossCeilingArea: 88.035 m2

# IfcSpace: Area:1699528
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.05.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.05.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSH; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 89.82 m2; NetFloorArea: 89.82 m2; GrossCeilingArea: 89.82 m2

# IfcSpace: Area:1699529
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.05.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.05.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 87.4095 m2; NetFloorArea: 87.4095 m2; GrossCeilingArea: 87.4095 m2

# IfcSpace: Area:1699531
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.06.01
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.06.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSK; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 83.002 m2; NetFloorArea: 83.002 m2; GrossCeilingArea: 83.002 m2

# IfcSpace: Area:1699532
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.06.02
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.06.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSK; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.9 m2; NetFloorArea: 90.9 m2; GrossCeilingArea: 90.9 m2

# IfcSpace: Area:1699533
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.06.03
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.06.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 91.3625 m2; NetFloorArea: 91.3625 m2; GrossCeilingArea: 91.3625 m2

# IfcSpace: Area:1699534
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.06.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.06.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSK; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 88.035 m2; NetFloorArea: 88.035 m2; GrossCeilingArea: 88.035 m2

# IfcSpace: Area:1699535
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.06.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.06.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSK; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 89.82 m2; NetFloorArea: 89.82 m2; GrossCeilingArea: 89.82 m2

# IfcSpace: Area:1699536
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.06.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: BVO; BouwwerkNummer: 01; EenheidNummer: 01.06.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 87.4095 m2; NetFloorArea: 87.4095 m2; GrossCeilingArea: 87.4095 m2

# IfcSpace: Area:1699538
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.06.06
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.06.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSH; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 83.002 m2; NetFloorArea: 83.002 m2; GrossCeilingArea: 83.002 m2

# IfcSpace: Area:1699539
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.06.05
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: BVO; BouwwerkNummer: 02; EenheidNummer: 02.06.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.9 m2; NetFloorArea: 90.9 m2; GrossCeilingArea: 90.9 m2

# IfcSpace: Area:1699540
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.06.04
Pset_SpaceCommon - IsExternal: no; Reference: Area
Pset_SpaceHeaterTypeCommon - Reference: Area
