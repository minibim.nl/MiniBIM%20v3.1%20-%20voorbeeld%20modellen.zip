Properties of the parts of a building model (IFC4), part 2 of 2

# IfcSpace: 02.08.05
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 78.3975 m2; NetFloorArea: 78.3975 m2; GrossCeilingArea: 78.3975 m2

# IfcSpace: 02.08.06
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.08.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSH; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 70.6432 m2; NetFloorArea: 70.6432 m2; GrossCeilingArea: 70.6432 m2

# IfcSpace: 71_PA_Parkeerplaats auto:openbaar 90° - 2400 (24)
Type - PredefinedType: USERDEFINED; Classification: 71.10 vaste verkeersvoorzieningen; standaard, algemeen (verzamelniveau) (NL-SfB); Material: markering
Pset_SpaceCommon - IsExternal: no; Reference: openbaar 90° - 2400
Pset_SpaceHeaterTypeCommon - Reference: openbaar 90° - 2400
MiniBIM ILS - Bepalingsmethode: NVO; BuitenruimteSoort: Subruimte; BuitenruimteType: Parkeerplaats auto
Qto_SpaceBaseQuantities - Height: 2.4 m; GrossFloorArea: 12.312 m2; GrossCeilingArea: 15.0515 m2; GrossVolume: 0.06156 m3; NetVolume: 0.06156 m3

# IfcSpace: 71_PA_Parkeerplaats auto:stalling 90° - 2400 (74)
Type - Classification: 71.10 vaste verkeersvoorzieningen; standaard, algemeen (verzamelniveau) (NL-SfB); Material: markering
Pset_SpaceCommon - IsExternal: no; Reference: stalling 90° - 2400
Pset_SpaceHeaterTypeCommon - Reference: stalling 90° - 2400
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 00; RuimteSoort: Subruimte; RuimteType: Parkeerplaats auto
Qto_SpaceBaseQuantities - GrossFloorArea: 8.154 m2; GrossCeilingArea: 10.8875 m2; GrossVolume: 0.04077 m3; NetVolume: 0.04077 m3
Group: 00
Name | Height (m)
37 x Parkeerplaats auto | 4.53
37 x Parkeerplaats auto | 1.8

# IfcSpace: 71_PA_Parkeerplaats bakfiets:Parkeerplaats bakfiets (28)
Type - PredefinedType: USERDEFINED; Classification: 71.10 vaste verkeersvoorzieningen; standaard, algemeen (verzamelniveau) (NL-SfB); Material: parkeervak
Pset_SpaceCommon - IsExternal: no; Reference: Parkeerplaats bakfiets
Pset_SpaceHeaterTypeCommon - Reference: Parkeerplaats bakfiets
MiniBIM ILS - Bepalingsmethode: NVO; RuimteSoort: Subruimte; RuimteType: Parkeerplaats bakfiets
Qto_SpaceBaseQuantities - GrossFloorArea: 1.915 m2; GrossCeilingArea: 1.92958 m2; GrossVolume: 0.009575 m3; NetVolume: 0.009575 m3
Name | BouwwerkNummer = Group | Height (m)
14 x Parkeerplaats bakfiets | 01 | 1.915
14 x Parkeerplaats bakfiets | 02 | 1

# IfcSpace: 71_PA_Parkeerplaats fiets:Parkeerplaats fiets hoog (260)
Type - PredefinedType: USERDEFINED; Classification: 71.10 vaste verkeersvoorzieningen; standaard, algemeen (verzamelniveau) (NL-SfB); Material: markering
Pset_SpaceCommon - IsExternal: no; Reference: Parkeerplaats fiets hoog
Pset_SpaceHeaterTypeCommon - Reference: Parkeerplaats fiets hoog
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 00; RuimteSoort: Subruimte; RuimteType: Parkeerplaats fiets hoog
Qto_SpaceBaseQuantities - GrossFloorArea: 0.766 m2; GrossCeilingArea: 0.777575 m2; GrossVolume: 0.00383 m3; NetVolume: 0.00383 m3
Group: 00
Name | Height (m)
130 x Parkeerplaats fiets hoog | 1.915
130 x Parkeerplaats fiets hoog | 0.4

# IfcSpace: 71_PA_Parkeerplaats fiets:Parkeerplaats fiets laag (260)
Type - PredefinedType: USERDEFINED; Classification: 71.10 vaste verkeersvoorzieningen; standaard, algemeen (verzamelniveau) (NL-SfB); Material: markering
Pset_SpaceCommon - IsExternal: no; Reference: Parkeerplaats fiets laag
Pset_SpaceHeaterTypeCommon - Reference: Parkeerplaats fiets laag
MiniBIM ILS - Bepalingsmethode: NVO; BouwwerkNummer: 00; RuimteSoort: Subruimte; RuimteType: Parkeerplaats fiets laag
Qto_SpaceBaseQuantities - GrossFloorArea: 0.766 m2; GrossCeilingArea: 0.777575 m2; GrossVolume: 0.00383 m3; NetVolume: 0.00383 m3
Group: 00
Name | Height (m)
130 x Parkeerplaats fiets laag | 1.915
130 x Parkeerplaats fiets laag | 0.4

# IfcSpace: 71_PA_Parkeerplaats scooter:Parkeerplaats scooter (18)
Type - PredefinedType: USERDEFINED; Classification: 71.10 vaste verkeersvoorzieningen; standaard, algemeen (verzamelniveau) (NL-SfB); Material: parkeervak
Pset_SpaceCommon - IsExternal: no; Reference: Parkeerplaats scooter
Pset_SpaceHeaterTypeCommon - Reference: Parkeerplaats scooter
MiniBIM ILS - Bepalingsmethode: NVO; RuimteSoort: Subruimte; RuimteType: Parkeerplaats scooter
Qto_SpaceBaseQuantities - GrossFloorArea: 1.43625 m2; GrossCeilingArea: 1.44958 m2; GrossVolume: 0.00718125 m3; NetVolume: 0.00718125 m3
Name | BouwwerkNummer = Group | Height (m)
9 x Parkeerplaats scooter | 01 | 1.915
9 x Parkeerplaats scooter | 02 | 0.75

# IfcSpace: Area:1483386
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 576.745 m2; NetFloorArea: 530.529 m2; GrossCeilingArea: 576.745 m2

# IfcSpace: Area:1483416
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 576.745 m2; NetFloorArea: 530.529 m2; GrossCeilingArea: 576.745 m2

# IfcSpace: Area:1483436
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 576.745 m2; NetFloorArea: 530.529 m2; GrossCeilingArea: 576.745 m2

# IfcSpace: Area:1483450
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 576.745 m2; NetFloorArea: 530.529 m2; GrossCeilingArea: 576.745 m2

# IfcSpace: Area:1483467
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 576.745 m2; NetFloorArea: 530.529 m2; GrossCeilingArea: 576.745 m2

# IfcSpace: Area:1483481
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 576.745 m2; NetFloorArea: 530.529 m2; GrossCeilingArea: 576.745 m2

# IfcSpace: Area:1483498
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 576.745 m2; NetFloorArea: 530.529 m2; GrossCeilingArea: 576.745 m2

# IfcSpace: Area:1483512
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 576.745 m2; NetFloorArea: 530.529 m2; GrossCeilingArea: 576.745 m2

# IfcSpace: Area:1483529
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 576.745 m2; NetFloorArea: 530.529 m2; GrossCeilingArea: 576.745 m2

# IfcSpace: Area:1483543
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 576.745 m2; NetFloorArea: 530.529 m2; GrossCeilingArea: 576.745 m2

# IfcSpace: Area:1483560
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 576.745 m2; NetFloorArea: 530.529 m2; GrossCeilingArea: 576.745 m2

# IfcSpace: Area:1483562
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 576.745 m2; NetFloorArea: 530.529 m2; GrossCeilingArea: 576.745 m2

# IfcSpace: Area:1483567
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 576.745 m2; NetFloorArea: 530.529 m2; GrossCeilingArea: 576.745 m2

# IfcSpace: Area:1483569
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 576.745 m2; NetFloorArea: 530.529 m2; GrossCeilingArea: 576.745 m2

# IfcSpace: Area:1483574
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 442.17 m2; NetFloorArea: 395.954 m2; GrossCeilingArea: 442.17 m2

# IfcSpace: Area:1483576
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 442.17 m2; NetFloorArea: 395.954 m2; GrossCeilingArea: 442.17 m2

# IfcSpace: Area:1483580
In: 00 begane grond
LongName: Gebruiksfunctie; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 165.201 m2; NetFloorArea: 165.201 m2; GrossCeilingArea: 165.201 m2

# IfcSpace: Area:1483582
In: 00 begane grond
LongName: Gebruiksfunctie; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 165.201 m2; NetFloorArea: 165.201 m2; GrossCeilingArea: 165.201 m2

# IfcSpace: Area:1483595
In: 00 begane grond
LongName: Gebruiksfunctie; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 165.201 m2; NetFloorArea: 165.201 m2; GrossCeilingArea: 165.201 m2

# IfcSpace: Area:1483611
In: 00 begane grond
LongName: Gebruiksfunctie; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Kinderdagverblijf; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 276.114 m2; NetFloorArea: 276.114 m2; GrossCeilingArea: 276.114 m2

# IfcSpace: Area:1483627
In: 00 begane grond
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Bijeenkomstfunctie, Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 16.9595 m2; NetFloorArea: 16.9595 m2; GrossCeilingArea: 16.9595 m2

# IfcSpace: Area:1483717
In: 00 begane grond
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Parkeergarage stalling; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 110.912 m2; NetFloorArea: 110.912 m2; GrossCeilingArea: 110.912 m2

# IfcSpace: Area:1484199
In: -1 kelder
LongName: Gemeenschappelijke ruimte; Group: 00
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 00; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Fietsenstalling inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 443.696 m2; NetFloorArea: 443.696 m2; GrossCeilingArea: 443.696 m2

# IfcSpace: Area:1484202
In: -1 kelder
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 77.25 m2; NetFloorArea: 77.25 m2; GrossCeilingArea: 77.25 m2

# IfcSpace: Area:1484208
In: -1 kelder
LongName: Gemeenschappelijke ruimte; Group: 00
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 00; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Parkeergarage stalling; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 1858.39 m2; NetFloorArea: 1781.14 m2; GrossCeilingArea: 1858.39 m2

# IfcSpace: Area:1484238
In: -1 kelder
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 77.25 m2; NetFloorArea: 77.25 m2; GrossCeilingArea: 77.25 m2

# IfcSpace: Area:1488725
In: 00 begane grond
LongName: Gemeenschappelijk verblijfsgebied; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijk verblijfsgebied; GebiedsType: Huiskamer; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 81.6275 m2; NetFloorArea: 81.6275 m2; GrossCeilingArea: 81.6275 m2

# IfcSpace: Area:1488741
In: 00 begane grond
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 141.918 m2; NetFloorArea: 141.918 m2; GrossCeilingArea: 141.918 m2

# IfcSpace: Area:1488759
In: 00 begane grond
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Fietsenstalling inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 110.913 m2; NetFloorArea: 110.913 m2; GrossCeilingArea: 110.913 m2

# IfcSpace: Area:1488792
In: 00 begane grond
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Fietsenstalling inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 110.912 m2; NetFloorArea: 110.912 m2; GrossCeilingArea: 110.912 m2

# IfcSpace: Area:1488824
In: 00 begane grond
LongName: Gemeenschappelijk verblijfsgebied; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijk verblijfsgebied; GebiedsType: Huiskamer; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 81.6275 m2; NetFloorArea: 81.6275 m2; GrossCeilingArea: 81.6275 m2

# IfcSpace: Area:1488842
In: 00 begane grond
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3.9 m; GrossFloorArea: 158.877 m2; NetFloorArea: 158.877 m2; GrossCeilingArea: 158.877 m2

# IfcSpace: Area:1489604
In: 01 eerste verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490290
In: 01 eerste verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490750
In: 02 tweede verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490752
In: 02 tweede verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490756
In: 03 derde verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490758
In: 03 derde verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490762
In: 04 vierde verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490764
In: 04 vierde verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490768
In: 05 vijfde verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490770
In: 05 vijfde verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490774
In: 06 zesde verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490776
In: 06 zesde verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490780
In: 07 zevende verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490782
In: 07 zevende verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490786
In: 08 achtste verdieping
LongName: Gemeenschappelijke ruimte; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490788
In: 08 achtste verdieping
LongName: Gemeenschappelijke ruimte; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 46.216 m2; NetFloorArea: 46.216 m2; GrossCeilingArea: 46.216 m2

# IfcSpace: Area:1490931
In: -1 kelder
LongName: Gemeenschappelijke ruimte; Group: 00
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 00; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Berging inpandig; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 86.9688 m2; NetFloorArea: 86.9688 m2; GrossCeilingArea: 86.9688 m2

# IfcSpace: Area:1490997
In: -1 kelder
LongName: Gemeenschappelijke ruimte; Group: 00
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 00; GebiedsSoort: Gemeenschappelijke ruimte; GebiedsType: Verkeersruimte; Gebruiksbestemming: Overige gebruiksfunctie
Qto_SpaceBaseQuantities - Height: 3.2 m; GrossFloorArea: 43.285 m2; NetFloorArea: 43.285 m2; GrossCeilingArea: 43.285 m2

# IfcSpace: Area:1491118
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 165.201 m2; NetFloorArea: 165.201 m2; GrossCeilingArea: 165.201 m2

# IfcSpace: Area:1491128
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 165.201 m2; NetFloorArea: 165.201 m2; GrossCeilingArea: 165.201 m2

# IfcSpace: Area:1491145
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Woongebied; Gebruiksbestemming: Woonfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 165.201 m2; NetFloorArea: 165.201 m2; GrossCeilingArea: 165.201 m2

# IfcSpace: Area:1491190
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Bepalingsmethode: BVO; BouwwerkNummer: 02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Kinderdagverblijf; Gebruiksbestemming: Bijeenkomstfunctie
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 165.201 m2; NetFloorArea: 165.201 m2; GrossCeilingArea: 165.201 m2
