Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [ContentGUID: 7b0fba1c-e461-43e6-a004-74300536da52, VersionGUID: 9bf6d295-1580-4b8e-9407-3409d76a7676, NumberOfSaves: 138], Options [Excluded Entities: IfcGroup;], CoordinateReference [CoordinateBase: Survey Point, ProjectSite: Internal]
File name: MiniBIM 3.1 SO_Ruimtelijke Elementen_VORM.ifc
Time: 2025-10-21T10:39:23+02:00
Organization: VORM Holding B.V.
Written by: IfcOpenShell 0.8.2
Made in: Bonsai 0.8.2

# IfcProject, 0000
LongName: Voorbeelmodel MiniBIM 3.1 SO-fase; Phase: PROJECTFASE

# IfcSite, Schiehaven
RefLatitude: 51, 54, 13, 78253; RefLongitude: 4, 27, 15, 99642; RefElevation: 3.5 m
Pset_SiteCommon - Reference: Project Information

# IfcBuilding, VORM huis
LongName: VORM huis
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 10; IsLandmarked: no
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; AboveGround: no
Pset_BuildingSystemCommon - Reference: Project Information

# IfcBuildingStorey: Level:Level bouwniveau (PBP) (11)
In: VORM huis
Pset_BuildingStoreyCommon - Reference: Level bouwniveau (PBP)
Name | LongName | Elevation (m) | EntranceLevel | AboveGround
-1 kelder | -1 kelder | -3.2 | no | no
00 begane grond | begane grond | 0 | yes | yes
01 eerste verdieping | 01 eerste verdieping | 3.9 | no | yes
02 tweede verdieping | 02 tweede verdieping | 6.9 | no | yes
03 derde verdieping | 03 derde verdieping | 9.9 | no | yes
04 vierde verdieping | 04 vierde verdieping | 12.9 | no | yes
05 vijfde verdieping | 05 vijfde verdieping | 15.9 | no | yes
06 zesde verdieping | 06 zesde verdieping | 18.9 | no | yes
07 zevende verdieping | 07 zevende verdieping | 21.9 | no | yes
08 achtste verdieping | 08 achtste verdieping | 24.9 | no | yes
09 negende verdieping | 09 negende verdieping | 27.9 | no | yes

# IfcSpace: 01.00.01 (2)
LongName: Gebruiksfunctie; Group: 01; 01.00.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 4 kamer; Segment: VSK; WoningType: A
Qto_SpaceBaseQuantities - GrossFloorArea: 47.4875 m2; NetFloorArea: 47.4875 m2; GrossCeilingArea: 47.4875 m2
Name | In | Height (m)
01.00.01 | 00 begane grond | 3.9
01.00.01 | 01 eerste verdieping | 3

# IfcSpace: 01.00.02 (2)
LongName: Gebruiksfunctie; Group: 01; 01.00.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord; Programma: 4 kamer; Segment: VSK; WoningType: B
Qto_SpaceBaseQuantities - GrossFloorArea: 47.4875 m2; NetFloorArea: 47.4875 m2; GrossCeilingArea: 47.4875 m2
Name | In | Height (m)
01.00.02 | 00 begane grond | 3.9
01.00.02 | 01 eerste verdieping | 3

# IfcSpace: 01.00.03 (2)
LongName: Gebruiksfunctie; Group: 01; 01.00.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 4 kamer; Segment: VSK; WoningType: A
Qto_SpaceBaseQuantities - GrossFloorArea: 47.4875 m2; NetFloorArea: 47.4875 m2; GrossCeilingArea: 47.4875 m2
Name | In | Height (m)
01.00.03 | 00 begane grond | 3.9
01.00.03 | 01 eerste verdieping | 3

# IfcSpace: 01.00.04 (2)
LongName: Gebruiksfunctie; Group: 01; 01.00.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 4 kamer; Segment: VSK; WoningType: A
Qto_SpaceBaseQuantities - GrossFloorArea: 47.4875 m2; NetFloorArea: 47.4875 m2; GrossCeilingArea: 47.4875 m2
Name | In | Height (m)
01.00.04 | 00 begane grond | 3.9
01.00.04 | 01 eerste verdieping | 3

# IfcSpace: 01.00.05 (2)
LongName: Gebruiksfunctie; Group: 01; 01.00.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid; Programma: 4 kamer; Segment: VSK; WoningType: B
Qto_SpaceBaseQuantities - GrossFloorArea: 47.4875 m2; NetFloorArea: 47.4875 m2; GrossCeilingArea: 47.4875 m2
Name | In | Height (m)
01.00.05 | 00 begane grond | 3.9
01.00.05 | 01 eerste verdieping | 3

# IfcSpace: 01.00.06 (2)
LongName: Gebruiksfunctie; Group: 01; 01.00.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.00.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 4 kamer; Segment: VSK; WoningType: A
Qto_SpaceBaseQuantities - GrossFloorArea: 47.4875 m2; NetFloorArea: 47.4875 m2; GrossCeilingArea: 47.4875 m2
Name | In | Height (m)
01.00.06 | 00 begane grond | 3.9
01.00.06 | 01 eerste verdieping | 3

# IfcSpace: 01.01.01
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.01.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: C
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 86.3507 m2; NetFloorArea: 86.3507 m2; GrossCeilingArea: 86.3507 m2

# IfcSpace: 01.01.02
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.01.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: D
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.025 m2; NetFloorArea: 90.025 m2; GrossCeilingArea: 90.025 m2

# IfcSpace: 01.01.03
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.01.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: D
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.025 m2; NetFloorArea: 90.025 m2; GrossCeilingArea: 90.025 m2

# IfcSpace: 01.01.04
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.01.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.01.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: C
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 86.3507 m2; NetFloorArea: 86.3507 m2; GrossCeilingArea: 86.3507 m2

# IfcSpace: 01.02.01
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 01; 01.02.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSK; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 70.6432 m2; NetFloorArea: 70.6432 m2; GrossCeilingArea: 70.6432 m2

# IfcSpace: 01.02.02
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 01; 01.02.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSK; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 78.3975 m2; NetFloorArea: 78.3975 m2; GrossCeilingArea: 78.3975 m2

# IfcSpace: 01.02.03
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 01; 01.02.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 81.465 m2; NetFloorArea: 81.465 m2; GrossCeilingArea: 81.465 m2

# IfcSpace: 01.02.04
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 01; 01.02.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSK; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 75.3187 m2; NetFloorArea: 75.3187 m2; GrossCeilingArea: 75.3187 m2

# IfcSpace: 01.02.05
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 01; 01.02.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSK; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.3962 m2; NetFloorArea: 77.3962 m2; GrossCeilingArea: 77.3962 m2

# IfcSpace: 01.02.06
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 01; 01.02.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.02.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.7907 m2; NetFloorArea: 77.7907 m2; GrossCeilingArea: 77.7907 m2

# IfcSpace: 01.03.01
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.03.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSK; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 70.6432 m2; NetFloorArea: 70.6432 m2; GrossCeilingArea: 70.6432 m2

# IfcSpace: 01.03.02
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.03.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSK; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 78.3975 m2; NetFloorArea: 78.3975 m2; GrossCeilingArea: 78.3975 m2

# IfcSpace: 01.03.03
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.03.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 81.465 m2; NetFloorArea: 81.465 m2; GrossCeilingArea: 81.465 m2

# IfcSpace: 01.03.04
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.03.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSK; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 75.3187 m2; NetFloorArea: 75.3187 m2; GrossCeilingArea: 75.3187 m2

# IfcSpace: 01.03.05
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.03.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSK; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.3962 m2; NetFloorArea: 77.3962 m2; GrossCeilingArea: 77.3962 m2

# IfcSpace: 01.03.06
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.03.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.03.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.7907 m2; NetFloorArea: 77.7907 m2; GrossCeilingArea: 77.7907 m2

# IfcSpace: 01.04.01
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.04.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSK; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 70.6432 m2; NetFloorArea: 70.6432 m2; GrossCeilingArea: 70.6432 m2

# IfcSpace: 01.04.02
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.04.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSK; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 78.3975 m2; NetFloorArea: 78.3975 m2; GrossCeilingArea: 78.3975 m2

# IfcSpace: 01.04.03
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.04.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 81.465 m2; NetFloorArea: 81.465 m2; GrossCeilingArea: 81.465 m2

# IfcSpace: 01.04.04
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.04.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSK; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 75.3187 m2; NetFloorArea: 75.3187 m2; GrossCeilingArea: 75.3187 m2

# IfcSpace: 01.04.05
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.04.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSK; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.3962 m2; NetFloorArea: 77.3962 m2; GrossCeilingArea: 77.3962 m2

# IfcSpace: 01.04.06
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.04.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.04.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.7907 m2; NetFloorArea: 77.7907 m2; GrossCeilingArea: 77.7907 m2

# IfcSpace: 01.05.01
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.05.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSK; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 70.6432 m2; NetFloorArea: 70.6432 m2; GrossCeilingArea: 70.6432 m2

# IfcSpace: 01.05.02
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.05.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSK; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 78.3975 m2; NetFloorArea: 78.3975 m2; GrossCeilingArea: 78.3975 m2

# IfcSpace: 01.05.03
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.05.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 81.465 m2; NetFloorArea: 81.465 m2; GrossCeilingArea: 81.465 m2

# IfcSpace: 01.05.04
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.05.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSK; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 75.3187 m2; NetFloorArea: 75.3187 m2; GrossCeilingArea: 75.3187 m2

# IfcSpace: 01.05.05
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.05.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSK; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.3962 m2; NetFloorArea: 77.3962 m2; GrossCeilingArea: 77.3962 m2

# IfcSpace: 01.05.06
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.05.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.05.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.7907 m2; NetFloorArea: 77.7907 m2; GrossCeilingArea: 77.7907 m2

# IfcSpace: 01.06.01
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.06.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSK; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 70.6432 m2; NetFloorArea: 70.6432 m2; GrossCeilingArea: 70.6432 m2

# IfcSpace: 01.06.02
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.06.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSK; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 78.3975 m2; NetFloorArea: 78.3975 m2; GrossCeilingArea: 78.3975 m2

# IfcSpace: 01.06.03
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.06.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 81.465 m2; NetFloorArea: 81.465 m2; GrossCeilingArea: 81.465 m2

# IfcSpace: 01.06.04
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.06.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSK; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 75.3187 m2; NetFloorArea: 75.3187 m2; GrossCeilingArea: 75.3187 m2

# IfcSpace: 01.06.05
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.06.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSK; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.3962 m2; NetFloorArea: 77.3962 m2; GrossCeilingArea: 77.3962 m2

# IfcSpace: 01.06.06
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 01; 01.06.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.06.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.7907 m2; NetFloorArea: 77.7907 m2; GrossCeilingArea: 77.7907 m2

# IfcSpace: 01.07.01
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 01; 01.07.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSK; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 70.6432 m2; NetFloorArea: 70.6432 m2; GrossCeilingArea: 70.6432 m2

# IfcSpace: 01.07.02
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 01; 01.07.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSK; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 78.3975 m2; NetFloorArea: 78.3975 m2; GrossCeilingArea: 78.3975 m2

# IfcSpace: 01.07.03
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 01; 01.07.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 81.465 m2; NetFloorArea: 81.465 m2; GrossCeilingArea: 81.465 m2

# IfcSpace: 01.07.04
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 01; 01.07.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSK; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 75.3187 m2; NetFloorArea: 75.3187 m2; GrossCeilingArea: 75.3187 m2

# IfcSpace: 01.07.05
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 01; 01.07.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSK; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.3962 m2; NetFloorArea: 77.3962 m2; GrossCeilingArea: 77.3962 m2

# IfcSpace: 01.07.06
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 01; 01.07.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.07.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.7907 m2; NetFloorArea: 77.7907 m2; GrossCeilingArea: 77.7907 m2

# IfcSpace: 01.08.01
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.08.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSK; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 70.6432 m2; NetFloorArea: 70.6432 m2; GrossCeilingArea: 70.6432 m2

# IfcSpace: 01.08.02
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.08.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSK; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 78.3975 m2; NetFloorArea: 78.3975 m2; GrossCeilingArea: 78.3975 m2

# IfcSpace: 01.08.03
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.08.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSK; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 81.465 m2; NetFloorArea: 81.465 m2; GrossCeilingArea: 81.465 m2

# IfcSpace: 01.08.04
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.08.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSK; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 75.3187 m2; NetFloorArea: 75.3187 m2; GrossCeilingArea: 75.3187 m2

# IfcSpace: 01.08.05
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.08.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSK; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.3962 m2; NetFloorArea: 77.3962 m2; GrossCeilingArea: 77.3962 m2

# IfcSpace: 01.08.06
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 01; 01.08.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Particulier; Bepalingsmethode: GO; BouwwerkNummer: 01; EenheidNummer: 01.08.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSK; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.7907 m2; NetFloorArea: 77.7907 m2; GrossCeilingArea: 77.7907 m2

# IfcSpace: 02.00.01 (2)
LongName: Gebruiksfunctie; Group: 02; 02.00.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 4 kamer; Segment: VSH; WoningType: A
Qto_SpaceBaseQuantities - GrossFloorArea: 47.4875 m2; NetFloorArea: 47.4875 m2; GrossCeilingArea: 47.4875 m2
Name | In | Height (m)
02.00.01 | 00 begane grond | 3.9
02.00.01 | 01 eerste verdieping | 3

# IfcSpace: 02.00.02 (2)
LongName: Gebruiksfunctie; Group: 02; 02.00.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord; Programma: 4 kamer; Segment: VSH; WoningType: B
Qto_SpaceBaseQuantities - GrossFloorArea: 47.4875 m2; NetFloorArea: 47.4875 m2; GrossCeilingArea: 47.4875 m2
Name | In | Height (m)
02.00.02 | 00 begane grond | 3.9
02.00.02 | 01 eerste verdieping | 3

# IfcSpace: 02.00.03 (2)
LongName: Gebruiksfunctie; Group: 02; 02.00.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.00.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Maisonette; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 4 kamer; Segment: VSH; WoningType: A
Qto_SpaceBaseQuantities - GrossFloorArea: 47.4875 m2; NetFloorArea: 47.4875 m2; GrossCeilingArea: 47.4875 m2
Name | In | Height (m)
02.00.03 | 00 begane grond | 3.9
02.00.03 | 01 eerste verdieping | 3

# IfcSpace: 02.00.04 (2)
LongName: Gebruiksfunctie; Group: 02; 02.00.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Belegger; Bepalingsmethode: VVO; BouwwerkNummer: 02; EenheidNummer: 02.00.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Kinderdagverblijf; Gebruiksbestemming: Bijeenkomstfunctie
Name | In | Height (m) | GrossFloorArea (m2) = GrossCeilingArea (m2) | NetFloorArea (m2)
02.00.04 | 00 begane grond | 3.9 | 248.775 | 247.775
02.00.04 | 01 eerste verdieping | 3 | 143.462 | 143.462

# IfcSpace: 02.01.01
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.01.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: C
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 86.3507 m2; NetFloorArea: 86.3507 m2; GrossCeilingArea: 86.3507 m2

# IfcSpace: 02.01.02
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.01.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: D
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.025 m2; NetFloorArea: 90.025 m2; GrossCeilingArea: 90.025 m2

# IfcSpace: 02.01.03
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.01.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: D
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 90.025 m2; NetFloorArea: 90.025 m2; GrossCeilingArea: 90.025 m2

# IfcSpace: 02.01.04
In: 01 eerste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.01.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.01.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: C
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 86.3507 m2; NetFloorArea: 86.3507 m2; GrossCeilingArea: 86.3507 m2

# IfcSpace: 02.02.01
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 02; 02.02.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.7907 m2; NetFloorArea: 77.7907 m2; GrossCeilingArea: 77.7907 m2

# IfcSpace: 02.02.02
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 02; 02.02.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSH; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.3962 m2; NetFloorArea: 77.3962 m2; GrossCeilingArea: 77.3962 m2

# IfcSpace: 02.02.03
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 02; 02.02.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSH; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 75.3187 m2; NetFloorArea: 75.3187 m2; GrossCeilingArea: 75.3187 m2

# IfcSpace: 02.02.04
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 02; 02.02.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 81.465 m2; NetFloorArea: 81.465 m2; GrossCeilingArea: 81.465 m2

# IfcSpace: 02.02.05
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 02; 02.02.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 78.3975 m2; NetFloorArea: 78.3975 m2; GrossCeilingArea: 78.3975 m2

# IfcSpace: 02.02.06
In: 02 tweede verdieping
LongName: Gebruiksfunctie; Group: 02; 02.02.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.02.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSH; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 70.6432 m2; NetFloorArea: 70.6432 m2; GrossCeilingArea: 70.6432 m2

# IfcSpace: 02.03.01
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.03.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.7907 m2; NetFloorArea: 77.7907 m2; GrossCeilingArea: 77.7907 m2

# IfcSpace: 02.03.02
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.03.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSH; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.3962 m2; NetFloorArea: 77.3962 m2; GrossCeilingArea: 77.3962 m2

# IfcSpace: 02.03.03
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.03.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSH; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 75.3187 m2; NetFloorArea: 75.3187 m2; GrossCeilingArea: 75.3187 m2

# IfcSpace: 02.03.04
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.03.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 81.465 m2; NetFloorArea: 81.465 m2; GrossCeilingArea: 81.465 m2

# IfcSpace: 02.03.05
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.03.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 78.3975 m2; NetFloorArea: 78.3975 m2; GrossCeilingArea: 78.3975 m2

# IfcSpace: 02.03.06
In: 03 derde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.03.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.03.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSH; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 70.6432 m2; NetFloorArea: 70.6432 m2; GrossCeilingArea: 70.6432 m2

# IfcSpace: 02.04.01
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.04.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.7907 m2; NetFloorArea: 77.7907 m2; GrossCeilingArea: 77.7907 m2

# IfcSpace: 02.04.02
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.04.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSH; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.3962 m2; NetFloorArea: 77.3962 m2; GrossCeilingArea: 77.3962 m2

# IfcSpace: 02.04.03
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.04.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSH; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 75.3187 m2; NetFloorArea: 75.3187 m2; GrossCeilingArea: 75.3187 m2

# IfcSpace: 02.04.04
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.04.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 81.465 m2; NetFloorArea: 81.465 m2; GrossCeilingArea: 81.465 m2

# IfcSpace: 02.04.05
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.04.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 78.3975 m2; NetFloorArea: 78.3975 m2; GrossCeilingArea: 78.3975 m2

# IfcSpace: 02.04.06
In: 04 vierde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.04.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.04.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSH; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 70.6432 m2; NetFloorArea: 70.6432 m2; GrossCeilingArea: 70.6432 m2

# IfcSpace: 02.05.01
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.05.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.7907 m2; NetFloorArea: 77.7907 m2; GrossCeilingArea: 77.7907 m2

# IfcSpace: 02.05.02
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.05.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSH; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.3962 m2; NetFloorArea: 77.3962 m2; GrossCeilingArea: 77.3962 m2

# IfcSpace: 02.05.03
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.05.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSH; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 75.3187 m2; NetFloorArea: 75.3187 m2; GrossCeilingArea: 75.3187 m2

# IfcSpace: 02.05.04
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.05.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 81.465 m2; NetFloorArea: 81.465 m2; GrossCeilingArea: 81.465 m2

# IfcSpace: 02.05.05
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.05.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 78.3975 m2; NetFloorArea: 78.3975 m2; GrossCeilingArea: 78.3975 m2

# IfcSpace: 02.05.06
In: 05 vijfde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.05.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.05.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSH; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 70.6432 m2; NetFloorArea: 70.6432 m2; GrossCeilingArea: 70.6432 m2

# IfcSpace: 02.06.01
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.06.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.7907 m2; NetFloorArea: 77.7907 m2; GrossCeilingArea: 77.7907 m2

# IfcSpace: 02.06.02
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.06.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSH; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.3962 m2; NetFloorArea: 77.3962 m2; GrossCeilingArea: 77.3962 m2

# IfcSpace: 02.06.03
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.06.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSH; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 75.3187 m2; NetFloorArea: 75.3187 m2; GrossCeilingArea: 75.3187 m2

# IfcSpace: 02.06.04
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.06.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 81.465 m2; NetFloorArea: 81.465 m2; GrossCeilingArea: 81.465 m2

# IfcSpace: 02.06.05
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.06.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 78.3975 m2; NetFloorArea: 78.3975 m2; GrossCeilingArea: 78.3975 m2

# IfcSpace: 02.06.06
In: 06 zesde verdieping
LongName: Gebruiksfunctie; Group: 02; 02.06.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.06.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSH; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 70.6432 m2; NetFloorArea: 70.6432 m2; GrossCeilingArea: 70.6432 m2

# IfcSpace: 02.07.01
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 02; 02.07.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.7907 m2; NetFloorArea: 77.7907 m2; GrossCeilingArea: 77.7907 m2

# IfcSpace: 02.07.02
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 02; 02.07.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSH; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.3962 m2; NetFloorArea: 77.3962 m2; GrossCeilingArea: 77.3962 m2

# IfcSpace: 02.07.03
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 02; 02.07.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSH; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 75.3187 m2; NetFloorArea: 75.3187 m2; GrossCeilingArea: 75.3187 m2

# IfcSpace: 02.07.04
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 02; 02.07.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 81.465 m2; NetFloorArea: 81.465 m2; GrossCeilingArea: 81.465 m2

# IfcSpace: 02.07.05
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 02; 02.07.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.05; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, Oost; Programma: 3 kamer; Segment: VSH; WoningType: H
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 78.3975 m2; NetFloorArea: 78.3975 m2; GrossCeilingArea: 78.3975 m2

# IfcSpace: 02.07.06
In: 07 zevende verdieping
LongName: Gebruiksfunctie; Group: 02; 02.07.06
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.07.06; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Zuid, West; Programma: 3 kamer; Segment: VSH; WoningType: G
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 70.6432 m2; NetFloorArea: 70.6432 m2; GrossCeilingArea: 70.6432 m2

# IfcSpace: 02.08.01
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.08.01
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.01; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: West; Programma: 3 kamer; Segment: VSH; WoningType: F
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.7907 m2; NetFloorArea: 77.7907 m2; GrossCeilingArea: 77.7907 m2

# IfcSpace: 02.08.02
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.08.02
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.02; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, West; Programma: 3 kamer; Segment: VSH; WoningType: E
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 77.3962 m2; NetFloorArea: 77.3962 m2; GrossCeilingArea: 77.3962 m2

# IfcSpace: 02.08.03
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.08.03
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.03; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Noord, Oost; Programma: 3 kamer; Segment: VSH; WoningType: J
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 75.3187 m2; NetFloorArea: 75.3187 m2; GrossCeilingArea: 75.3187 m2

# IfcSpace: 02.08.04
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.08.04
Pset_SpaceCommon - Reference: Area; IsExternal: no
Pset_SpaceHeaterTypeCommon - Reference: Area
MiniBIM ILS - Afnemer: Corporatie; Bepalingsmethode: GO; BouwwerkNummer: 02; EenheidNummer: 02.08.04; GebiedsSoort: Gebruiksfunctie; GebiedsType: Appartement; Gebruiksbestemming: Woonfunctie; Orientatie: Oost; Programma: 3 kamer; Segment: VSH; WoningType: I
Qto_SpaceBaseQuantities - Height: 3 m; GrossFloorArea: 81.465 m2; NetFloorArea: 81.465 m2; GrossCeilingArea: 81.465 m2

# IfcSpace: 02.08.05
In: 08 achtste verdieping
LongName: Gebruiksfunctie; Group: 02; 02.08.05
Pset_SpaceCommon - Reference: Area; IsExternal: no
